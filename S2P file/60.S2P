!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:36:27 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -64.07 dB at 60 MHz (marker M1); lowest = -72.2 dB at 17.92 GHz (marker M2)
!   lowest |S11| = -80.1 dB at 12.15 GHz (marker M3), VSWR 1.00, Z = 50 + j0.00916 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (253.1 MHz wide, 1.43 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -47.0 to -11.1 dB; largest |S21 - S12| = 4e-05
!   the Smith chart shows 10.89 GHz to 13.68 GHz only
!   S11 on the Smith chart (normalised r, x): 10.89 GHz: 1.23, -0.03; 13.02 GHz: 1.03, +0.19; 13.68 GHz: 0.82, +0.28
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -25.6  -64.3  -64.3  -26.6
! 60 MHz  -26.3  -64.1  -64.1  -28.8
! 1.53 GHz  -27.8  -65.5  -65.6  -16.6
! 3.01 GHz  -26.3  -66.2  -66.2  -21.7
! 4.01 GHz  -28.4  -66.7  -66.7  -19.3
! 4.72 GHz  -35.5  -67.2  -67.2  -20.2
! 4.79 GHz  -29.6  -67.1  -67.0  -19.0
! 4.98 GHz  -34.7  -67.0  -67.1  -21.8
! 5.22 GHz  -33.6  -67.2  -67.2  -26.2
! 5.51 GHz  -35.9  -67.4  -67.3  -41.4
! 6.01 GHz  -25.9  -67.8  -67.8  -21.7
! 7.94 GHz  -19.5  -68.5  -68.5  -15.5
! 9.01 GHz  -15.1  -68.9  -69.0  -11.6
! 10.89 GHz  -19.5  -70.1  -70.3  -12.2
! 12.01 GHz  -49.6  -70.3  -70.4  -14.3
! 12.08 GHz  -20.2  -70.5  -70.5  -14.4
! 12.15 GHz  -80.1  -70.4  -70.2  -14.8
! 13.02 GHz  -20.7  -70.1  -70.3  -17.1
! 13.68 GHz  -14.8  -70.6  -70.6  -18.5
! 15.01 GHz  -15.0  -71.1  -71.1  -21.7
! 17.92 GHz  -11.6  -72.2  -71.9  -13.7
! 18 GHz  -10.6  -72.0  -71.8  -13.1
