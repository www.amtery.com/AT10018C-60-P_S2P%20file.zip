!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:04:08 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -36.40 dB at 10 MHz (marker M1); lowest = -45.5 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -47.6 dB at 11.38 GHz (marker M3), VSWR 1.01, Z = 50.4 - j0.151 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.62 GHz to 17.73 GHz (104.2 MHz wide, 0.589 % of centre); 17.76 GHz to 17.86 GHz (99.35 MHz wide, 0.558 % of centre) (the widest 3 of 4)
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.00063
!   the Smith chart shows 10.22 GHz to 12.76 GHz only
!   S11 on the Smith chart (normalised r, x): 10.22 GHz: 1.14, +0.14; 10.7 GHz: 1.18, -0.14; 12.76 GHz: 1.05, +0.24
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.8  -36.4  -36.4  -24.2
! 1.72 GHz  -20.8  -37.8  -37.8  -17.4
! 3.01 GHz  -24.8  -38.5  -38.5  -20.7
! 3.85 GHz  -35.7  -38.8  -38.8  -22.9
! 4.13 GHz  -29.4  -39.0  -39.0  -19.4
! 4.85 GHz  -22.6  -39.4  -39.4  -19.6
! 5.6 GHz  -27.9  -39.8  -39.8  -30.5
! 6.01 GHz  -24.7  -40.1  -40.2  -22.2
! 7.04 GHz  -25.7  -40.5  -40.5  -18.3
! 7.96 GHz  -16.3  -41.2  -41.3  -13.5
! 9.01 GHz  -14.2  -42.0  -42.0  -12.1
! 9.59 GHz  -17.9  -42.3  -42.4  -12.0
! 10.22 GHz  -20.7  -42.4  -42.5  -13.4
! 10.7 GHz  -19.6  -42.5  -42.6  -14.2
! 11.38 GHz  -47.6  -42.5  -42.6  -14.1
! 12.01 GHz  -32.8  -42.6  -42.7  -14.5
! 12.76 GHz  -18.7  -42.9  -43.0  -17.0
! 13.51 GHz  -19.2  -43.2  -43.1  -18.6
! 15.01 GHz  -14.5  -43.8  -43.9  -19.7
! 16.8 GHz  -17.4  -45.0  -45.1  -13.7
! 17.89 GHz  -9.2  -45.5  -45.6  -22.4
! 18 GHz  -10.0  -45.4  -45.5  -18.9
