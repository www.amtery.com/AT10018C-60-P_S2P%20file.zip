!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:16:55 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -24.32 dB at 10 MHz (marker M1); lowest = -34.4 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -53.3 dB at 3.4 GHz (marker M3), VSWR 1.00, Z = 50 - j0.215 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -35.6 to -10.4 dB; largest |S21 - S12| = 0.0025
!   the Smith chart shows 10 MHz to 9.08 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -23.9  -24.3  -24.3  -24.2
! 2.37 GHz  -30.3  -26.1  -26.1  -17.3
! 2.78 GHz  -37.7  -26.3  -26.3  -17.9
! 3.01 GHz  -31.8  -26.4  -26.4  -18.8
! 3.4 GHz  -53.3  -26.6  -26.6  -22.0
! 4.02 GHz  -29.5  -26.9  -26.9  -23.7
! 4.2 GHz  -31.9  -27.0  -27.0  -23.6
! 4.98 GHz  -39.8  -27.2  -27.2  -20.0
! 5.3 GHz  -31.1  -27.3  -27.3  -21.9
! 5.74 GHz  -34.3  -27.5  -27.5  -29.6
! 6.01 GHz  -31.1  -27.8  -27.8  -23.6
! 6.94 GHz  -22.9  -28.5  -28.5  -16.9
! 7.6 GHz  -20.3  -28.7  -28.8  -16.6
! 9.01 GHz  -15.3  -29.4  -29.4  -14.5
! 11.33 GHz  -20.2  -30.0  -30.0  -14.1
! 12.01 GHz  -27.6  -30.3  -30.4  -15.2
! 13.86 GHz  -18.8  -31.4  -31.7  -21.3
! 15.01 GHz  -17.4  -31.8  -31.9  -15.1
! 16.26 GHz  -19.2  -32.2  -32.3  -25.7
! 16.95 GHz  -20.3  -33.0  -33.1  -14.3
! 17.88 GHz  -11.0  -34.4  -34.4  -11.4
! 18 GHz  -11.9  -34.3  -34.4  -12.0
