!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:49:36 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -50.45 dB at 10 MHz (marker M1); lowest = -59.1 dB at 17.87 GHz (marker M2)
!   lowest |S11| = -75.8 dB at 720 MHz (marker M3), VSWR 1.00, Z = 50 + j0.00747 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (252.4 MHz wide, 1.42 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.00013
!   the Smith chart shows 10 MHz to 9.11 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -61.0  -50.5  -50.4  -24.3
! 110 MHz  -46.2  -50.9  -50.9  -25.9
! 250 MHz  -71.5  -51.0  -51.0  -25.1
! 390 MHz  -41.0  -51.1  -51.1  -23.9
! 720 MHz  -75.8  -51.3  -51.3  -21.2
! 860 MHz  -38.0  -51.3  -51.3  -20.3
! 2.12 GHz  -32.3  -51.9  -51.9  -17.6
! 2.33 GHz  -36.6  -52.0  -52.0  -17.8
! 2.58 GHz  -34.9  -52.1  -52.1  -18.9
! 3.01 GHz  -31.4  -52.3  -52.3  -20.7
! 3.99 GHz  -37.8  -52.7  -52.7  -21.1
! 4.17 GHz  -33.7  -52.8  -52.8  -19.6
! 4.73 GHz  -27.6  -53.1  -53.1  -19.2
! 5.6 GHz  -24.4  -53.7  -53.7  -30.4
! 6.01 GHz  -21.3  -53.9  -54.0  -22.2
! 9.01 GHz  -15.7  -55.7  -55.8  -12.1
! 11.64 GHz  -20.6  -56.3  -56.4  -14.2
! 12.01 GHz  -31.9  -56.2  -56.3  -14.5
! 15.01 GHz  -14.3  -57.4  -57.5  -19.7
! 16.8 GHz  -16.3  -58.5  -58.7  -13.7
! 17.87 GHz  -9.8  -59.1  -59.1  -21.9
! 18 GHz  -10.5  -59.0  -59.1  -18.9
