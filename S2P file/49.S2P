!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:48:44 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -53.02 dB at 60 MHz (marker M1); lowest = -61.2 dB at 17.9 GHz (marker M2)
!   lowest |S11| = -56.5 dB at 3.26 GHz (marker M3), VSWR 1.00, Z = 49.9 - j0.0875 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.62 GHz to 17.73 GHz (109.8 MHz wide, 0.621 % of centre); 17.75 GHz to 17.86 GHz (108 MHz wide, 0.607 % of centre) (the widest 3 of 4)
!   |S22| runs from -47.4 to -11.1 dB; largest |S21 - S12| = 0.00012
!   the Smith chart shows 10 MHz to 8.95 GHz only
!   S11 on the Smith chart (normalised r, x): 10 MHz: 1.30, -0.02; 3.17 GHz: 0.93, -0.04; 8.95 GHz: 1.22, +0.02
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.7  -53.2  -53.2  -26.6
! 60 MHz  -18.6  -53.0  -53.0  -28.8
! 1.53 GHz  -20.8  -54.6  -54.6  -16.6
! 3.01 GHz  -27.3  -55.3  -55.3  -21.7
! 3.17 GHz  -27.7  -55.4  -55.4  -23.9
! 3.26 GHz  -56.5  -55.5  -55.5  -23.0
! 3.33 GHz  -32.2  -55.5  -55.5  -26.2
! 4.03 GHz  -25.9  -55.7  -55.7  -19.2
! 4.72 GHz  -28.2  -56.1  -56.1  -20.2
! 5.22 GHz  -37.2  -56.3  -56.3  -26.2
! 5.51 GHz  -46.2  -56.5  -56.5  -41.7
! 6.01 GHz  -31.8  -56.8  -56.8  -21.6
! 6.32 GHz  -28.5  -57.0  -56.9  -19.1
! 7.13 GHz  -18.2  -57.4  -57.4  -16.2
! 8.95 GHz  -19.9  -58.4  -58.4  -12.3
! 9.01 GHz  -14.9  -58.5  -58.5  -11.6
! 10.6 GHz  -20.0  -58.7  -58.8  -12.2
! 12.01 GHz  -25.1  -59.3  -59.4  -14.3
! 12.34 GHz  -20.9  -59.5  -59.5  -15.2
! 15.01 GHz  -15.6  -59.8  -59.9  -21.7
! 17.9 GHz  -9.8  -61.2  -61.2  -13.8
! 18 GHz  -10.2  -61.2  -61.3  -13.1
