!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:23:53 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -18.45 dB at 10 MHz (marker M1); lowest = -27.6 dB at 17.31 GHz (marker M2)
!   lowest |S11| = -61.2 dB at 250 MHz (marker M3), VSWR 1.00, Z = 49.9 - j0.07 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.87 GHz (252.6 MHz wide, 1.42 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -39.3 to -9.6 dB; largest |S21 - S12| = 0.0051
!   the Smith chart shows 10 MHz to 8.71 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -59.2  -18.5  -18.5  -16.3
! 250 MHz  -61.2  -19.1  -19.1  -21.0
! 860 MHz  -37.1  -19.5  -19.5  -20.2
! 3.01 GHz  -31.6  -20.5  -20.5  -20.0
! 4.33 GHz  -34.1  -21.1  -21.1  -15.9
! 4.78 GHz  -32.2  -21.3  -21.3  -34.0
! 5.11 GHz  -25.9  -21.4  -21.4  -19.2
! 5.53 GHz  -25.2  -21.6  -21.6  -31.1
! 6.01 GHz  -21.2  -21.9  -21.9  -23.6
! 6.69 GHz  -19.8  -22.7  -22.6  -13.4
! 7.16 GHz  -19.5  -22.2  -22.2  -38.8
! 7.64 GHz  -21.3  -22.7  -22.8  -14.5
! 9.01 GHz  -15.6  -23.3  -23.3  -12.7
! 12.01 GHz  -31.5  -24.2  -24.3  -15.3
! 13.37 GHz  -13.9  -25.0  -25.0  -17.0
! 13.69 GHz  -15.3  -25.2  -25.2  -28.7
! 14.05 GHz  -13.0  -25.7  -25.8  -15.8
! 15.01 GHz  -14.4  -26.1  -26.1  -16.1
! 15.36 GHz  -13.8  -26.1  -26.0  -30.6
! 16.34 GHz  -12.9  -26.9  -27.0  -13.0
! 17.31 GHz  -11.0  -27.6  -27.6  -12.6
! 18 GHz  -10.6  -27.2  -27.2  -24.0
