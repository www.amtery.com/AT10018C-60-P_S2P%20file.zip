!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:14:39 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -26.33 dB at 10 MHz (marker M1); lowest = -36.3 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -60.2 dB at 3.41 GHz (marker M3), VSWR 1.00, Z = 50.1 + j0.0752 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -35.6 to -10.4 dB; largest |S21 - S12| = 0.002
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -27.6  -26.3  -26.3  -24.3
! 2.38 GHz  -33.9  -28.0  -28.0  -17.3
! 2.64 GHz  -31.1  -28.1  -28.1  -17.5
! 2.8 GHz  -47.3  -28.2  -28.2  -18.3
! 3.01 GHz  -34.4  -28.3  -28.3  -18.8
! 3.41 GHz  -60.2  -28.5  -28.5  -22.6
! 4.04 GHz  -29.8  -28.8  -28.8  -23.8
! 4.21 GHz  -32.9  -28.9  -28.9  -23.5
! 4.78 GHz  -53.9  -29.1  -29.1  -18.7
! 4.98 GHz  -34.7  -29.1  -29.1  -20.0
! 5.74 GHz  -30.5  -29.5  -29.5  -29.7
! 6.01 GHz  -27.5  -29.7  -29.7  -23.5
! 6.56 GHz  -22.8  -30.2  -30.2  -17.2
! 9.01 GHz  -16.3  -31.3  -31.4  -14.6
! 11.33 GHz  -19.4  -31.9  -31.9  -14.2
! 12.01 GHz  -26.2  -32.2  -32.3  -15.2
! 13.86 GHz  -19.1  -33.4  -33.6  -21.3
! 15.01 GHz  -17.5  -33.7  -33.8  -15.1
! 16.26 GHz  -20.3  -34.2  -34.2  -25.7
! 16.95 GHz  -21.1  -34.9  -35.0  -14.3
! 17.88 GHz  -11.3  -36.3  -36.3  -11.4
! 18 GHz  -12.3  -36.2  -36.3  -12.0
