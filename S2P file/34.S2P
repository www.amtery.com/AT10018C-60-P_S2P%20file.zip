!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:03:08 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -37.42 dB at 10 MHz (marker M1); lowest = -46.6 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -48.9 dB at 13.73 GHz (marker M3), VSWR 1.01, Z = 50.3 - j0.239 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.00056
!   the Smith chart shows 12.22 GHz to 15.18 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.1  -37.4  -37.4  -24.2
! 1.72 GHz  -20.0  -38.8  -38.8  -17.4
! 3.01 GHz  -23.4  -39.4  -39.4  -20.7
! 3.53 GHz  -25.2  -39.7  -39.7  -23.2
! 4.73 GHz  -23.8  -40.3  -40.2  -19.2
! 5.11 GHz  -22.9  -40.4  -40.4  -21.7
! 5.6 GHz  -24.8  -40.8  -40.8  -30.4
! 6.01 GHz  -29.1  -41.1  -41.2  -22.2
! 7.05 GHz  -27.1  -41.5  -41.5  -18.5
! 7.96 GHz  -17.0  -42.3  -42.3  -13.5
! 9.01 GHz  -15.1  -43.0  -43.0  -12.1
! 11.1 GHz  -23.2  -43.6  -43.6  -14.3
! 12.01 GHz  -22.5  -43.7  -43.7  -14.5
! 12.91 GHz  -19.8  -43.9  -44.0  -17.4
! 12.99 GHz  -30.6  -43.9  -43.9  -17.9
! 13.5 GHz  -23.9  -44.1  -44.1  -18.6
! 13.73 GHz  -48.9  -44.2  -44.2  -16.8
! 15.01 GHz  -17.5  -44.8  -44.9  -19.7
! 16.8 GHz  -17.4  -46.1  -46.1  -13.7
! 17.72 GHz  -11.9  -46.4  -46.5  -23.7
! 17.88 GHz  -10.2  -46.6  -46.6  -22.2
! 18 GHz  -11.4  -46.5  -46.6  -18.9
