!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:56:56 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -43.43 dB at 10 MHz (marker M1); lowest = -52.4 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -60.4 dB at 5.07 GHz (marker M3), VSWR 1.00, Z = 50.1 - j0.0411 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.62 GHz to 17.74 GHz (118.1 MHz wide, 0.668 % of centre); 17.75 GHz to 17.86 GHz (116.4 MHz wide, 0.654 % of centre) (the widest 3 of 4)
!   |S22| runs from -36.2 to -11.4 dB; largest |S21 - S12| = 0.00028
!   the Smith chart shows 10 MHz to 9.1 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -23.9  -43.4  -43.4  -24.2
! 1.72 GHz  -25.0  -44.8  -44.8  -17.4
! 3.01 GHz  -25.4  -45.4  -45.4  -20.7
! 3.53 GHz  -26.7  -45.7  -45.7  -23.2
! 4.46 GHz  -27.8  -46.1  -46.1  -19.8
! 4.54 GHz  -33.7  -46.2  -46.2  -17.4
! 4.63 GHz  -33.3  -46.2  -46.2  -18.2
! 4.8 GHz  -28.8  -46.3  -46.3  -18.3
! 5.07 GHz  -60.4  -46.4  -46.3  -21.0
! 5.28 GHz  -34.8  -46.5  -46.5  -24.4
! 5.44 GHz  -27.8  -46.6  -46.6  -28.6
! 5.6 GHz  -32.8  -46.8  -46.8  -30.4
! 6.01 GHz  -25.3  -47.1  -47.1  -22.2
! 7.95 GHz  -18.8  -48.2  -48.2  -13.7
! 9.01 GHz  -14.5  -48.9  -49.0  -12.1
! 10.95 GHz  -39.5  -49.4  -49.4  -14.4
! 11.31 GHz  -21.2  -49.5  -49.5  -14.1
! 12.01 GHz  -35.5  -49.5  -49.6  -14.5
! 15.01 GHz  -14.8  -50.8  -50.8  -19.7
! 16.8 GHz  -15.9  -51.9  -52.0  -13.7
! 17.88 GHz  -9.5  -52.4  -52.4  -22.2
! 18 GHz  -10.4  -52.3  -52.4  -18.9
