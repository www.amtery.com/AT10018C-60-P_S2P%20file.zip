!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:32:54 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -67.08 dB at 60 MHz (marker M1); lowest = -75.2 dB at 17.93 GHz (marker M2)
!   lowest |S11| = -76.6 dB at 720 MHz (marker M3), VSWR 1.00, Z = 50 - j0.0147 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (252.5 MHz wide, 1.42 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -47.6 to -11.1 dB; largest |S21 - S12| = 3.7e-05
!   the Smith chart shows 10 MHz to 9.01 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -61.0  -67.3  -67.3  -26.6
! 60 MHz  -45.5  -67.1  -67.1  -28.8
! 390 MHz  -40.7  -67.9  -68.0  -24.5
! 720 MHz  -76.6  -68.1  -68.1  -20.6
! 860 MHz  -37.9  -68.2  -68.2  -19.4
! 1.54 GHz  -38.1  -68.5  -68.5  -16.6
! 2.33 GHz  -37.0  -68.9  -68.9  -17.6
! 2.58 GHz  -35.6  -69.0  -69.0  -19.2
! 3.01 GHz  -31.2  -69.1  -69.1  -21.7
! 3.6 GHz  -33.0  -69.4  -69.4  -24.5
! 3.78 GHz  -41.3  -69.4  -69.4  -21.0
! 4.17 GHz  -34.3  -69.7  -69.6  -19.0
! 4.72 GHz  -27.4  -70.1  -70.1  -20.2
! 5.22 GHz  -23.6  -70.1  -70.1  -26.2
! 5.51 GHz  -26.1  -70.3  -70.3  -41.7
! 6.01 GHz  -21.5  -70.6  -70.6  -21.6
! 9.01 GHz  -15.9  -71.6  -71.6  -11.6
! 11.35 GHz  -21.8  -73.4  -73.3  -13.1
! 12.01 GHz  -29.9  -73.3  -73.3  -14.3
! 15.01 GHz  -14.4  -73.9  -74.1  -21.7
! 17.93 GHz  -13.1  -75.2  -74.7  -13.5
! 18 GHz  -10.5  -74.5  -74.9  -13.1
