!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:29:17 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -13.43 dB at 10 MHz (marker M1); lowest = -22.8 dB at 17.18 GHz (marker M2)
!   lowest |S11| = -56.1 dB at 4.68 GHz (marker M3), VSWR 1.00, Z = 50.1 + j0.0909 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (259.7 MHz wide, 1.46 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -42.9 to -9.6 dB; largest |S21 - S12| = 0.009
!   the Smith chart shows 10 MHz to 8.67 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -24.5  -13.4  -13.4  -15.5
! 470 MHz  -26.7  -14.3  -14.3  -28.1
! 3.01 GHz  -26.2  -15.6  -15.6  -20.3
! 4.32 GHz  -27.0  -16.1  -16.1  -16.4
! 4.68 GHz  -56.1  -16.3  -16.3  -25.2
! 5.54 GHz  -37.8  -16.6  -16.6  -31.5
! 6.01 GHz  -25.7  -16.9  -16.9  -23.0
! 6.7 GHz  -21.1  -17.7  -17.7  -13.2
! 7.16 GHz  -21.4  -17.3  -17.3  -40.7
! 7.53 GHz  -24.4  -17.7  -17.7  -15.2
! 9.01 GHz  -14.7  -18.4  -18.5  -12.7
! 12.01 GHz  -38.3  -19.4  -19.4  -15.3
! 12.6 GHz  -23.9  -19.8  -19.8  -13.1
! 12.97 GHz  -20.0  -20.1  -20.2  -25.8
! 13.36 GHz  -15.3  -20.1  -20.2  -16.7
! 13.69 GHz  -16.4  -20.3  -20.3  -29.6
! 14.04 GHz  -15.1  -20.9  -21.0  -15.8
! 15.01 GHz  -15.2  -21.3  -21.3  -16.1
! 15.35 GHz  -13.7  -21.3  -21.2  -30.3
! 16.33 GHz  -12.9  -22.0  -22.1  -13.2
! 17.18 GHz  -10.8  -22.8  -22.9  -11.9
! 18 GHz  -10.9  -22.4  -22.5  -24.4
