!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:39:38 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -61.04 dB at 60 MHz (marker M1); lowest = -68.9 dB at 17.97 GHz (marker M2)
!   lowest |S11| = -61.6 dB at 3.73 GHz (marker M3), VSWR 1.00, Z = 50 + j0.0796 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.62 GHz to 17.74 GHz (118.1 MHz wide, 0.668 % of centre); 17.74 GHz to 17.86 GHz (116.7 MHz wide, 0.655 % of centre) (the widest 3 of 4)
!   |S22| runs from -47.3 to -11.1 dB; largest |S21 - S12| = 5.5e-05
!   the Smith chart shows 10 MHz to 9.01 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -37.3  -61.2  -61.2  -26.6
! 60 MHz  -40.4  -61.0  -61.0  -28.8
! 840 MHz  -32.2  -62.2  -62.2  -19.5
! 1.01 GHz  -43.7  -62.2  -62.2  -18.6
! 1.53 GHz  -38.0  -62.5  -62.5  -16.6
! 2.34 GHz  -36.0  -63.0  -63.0  -17.7
! 2.75 GHz  -39.5  -63.1  -63.1  -19.9
! 3.01 GHz  -30.5  -63.2  -63.2  -21.7
! 3.61 GHz  -31.9  -63.5  -63.6  -24.0
! 3.73 GHz  -61.6  -63.5  -63.6  -22.7
! 3.99 GHz  -41.2  -63.6  -63.7  -19.9
! 4.16 GHz  -34.2  -63.7  -63.7  -18.7
! 4.85 GHz  -33.0  -64.0  -64.0  -20.8
! 5.23 GHz  -24.3  -64.2  -64.2  -26.4
! 5.51 GHz  -27.0  -64.4  -64.4  -41.6
! 6.01 GHz  -22.2  -64.7  -64.7  -21.7
! 9.01 GHz  -15.7  -66.0  -66.1  -11.6
! 11.64 GHz  -20.4  -66.7  -66.7  -13.4
! 12.01 GHz  -32.6  -67.2  -67.2  -14.3
! 15.01 GHz  -14.5  -67.8  -68.0  -21.7
! 17.97 GHz  -13.1  -68.9  -68.8  -12.7
! 18 GHz  -10.3  -68.8  -69.0  -13.1
