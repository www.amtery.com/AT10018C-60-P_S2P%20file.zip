!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:41:32 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -59.10 dB at 60 MHz (marker M1); lowest = -67.3 dB at 17.9 GHz (marker M2)
!   lowest |S11| = -56.1 dB at 4.76 GHz (marker M3), VSWR 1.00, Z = 49.9 - j0.144 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -47.3 to -11.1 dB; largest |S21 - S12| = 6.4e-05
!   the Smith chart shows 10 MHz to 9.01 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -27.4  -59.3  -59.3  -26.6
! 60 MHz  -28.8  -59.1  -59.1  -28.8
! 1.53 GHz  -32.4  -60.5  -60.6  -16.6
! 2.16 GHz  -28.9  -60.9  -60.9  -16.7
! 2.38 GHz  -34.8  -61.0  -61.0  -17.9
! 2.64 GHz  -30.4  -61.1  -61.1  -19.2
! 2.8 GHz  -40.7  -61.1  -61.1  -21.0
! 3.01 GHz  -32.8  -61.2  -61.2  -21.7
! 3.45 GHz  -37.7  -61.4  -61.4  -25.8
! 4.57 GHz  -32.0  -62.0  -62.0  -19.5
! 4.76 GHz  -56.1  -62.1  -62.1  -19.1
! 5.22 GHz  -26.3  -62.3  -62.2  -26.2
! 5.5 GHz  -31.9  -62.4  -62.4  -39.9
! 6.01 GHz  -25.1  -62.8  -62.7  -21.7
! 6.73 GHz  -24.0  -63.4  -63.4  -17.3
! 7.93 GHz  -21.3  -63.6  -63.7  -15.8
! 9.01 GHz  -17.1  -64.3  -64.3  -11.6
! 10.61 GHz  -20.1  -64.6  -64.6  -12.2
! 12.01 GHz  -25.8  -65.2  -65.4  -14.3
! 15.01 GHz  -17.1  -65.8  -65.8  -21.7
! 17.9 GHz  -11.8  -67.3  -67.3  -13.8
! 18 GHz  -12.1  -67.1  -67.1  -13.1
