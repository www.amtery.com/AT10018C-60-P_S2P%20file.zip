!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:37:31 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -63.05 dB at 60 MHz (marker M1); lowest = -70.9 dB at 17.86 GHz (marker M2)
!   lowest |S11| = -67.1 dB at 3.32 GHz (marker M3), VSWR 1.00, Z = 50 + j0.0242 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (250.4 MHz wide, 1.41 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -47.0 to -11.1 dB; largest |S21 - S12| = 3.8e-05
!   the Smith chart shows 10 MHz to 9.01 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -46.3  -63.2  -63.3  -26.6
! 60 MHz  -50.2  -63.0  -63.1  -28.8
! 540 MHz  -54.7  -64.0  -64.0  -22.7
! 860 MHz  -35.3  -64.1  -64.2  -19.5
! 980 MHz  -54.7  -64.2  -64.2  -18.6
! 1.53 GHz  -38.7  -64.5  -64.5  -16.6
! 2.33 GHz  -35.7  -64.9  -64.9  -17.6
! 2.58 GHz  -34.8  -65.0  -65.0  -19.2
! 3.01 GHz  -31.1  -65.1  -65.1  -21.7
! 3.32 GHz  -67.1  -65.3  -65.4  -25.9
! 3.98 GHz  -38.8  -65.6  -65.6  -20.2
! 4.16 GHz  -32.8  -65.6  -65.6  -18.7
! 4.72 GHz  -28.3  -66.1  -66.1  -20.2
! 5.22 GHz  -24.0  -66.1  -66.1  -26.2
! 5.51 GHz  -26.4  -66.3  -66.3  -41.3
! 6.01 GHz  -21.9  -66.6  -66.7  -21.7
! 9.01 GHz  -16.0  -67.9  -67.9  -11.6
! 11.35 GHz  -21.8  -69.1  -69.2  -13.1
! 12.01 GHz  -31.4  -68.9  -69.0  -14.3
! 15.01 GHz  -14.6  -69.7  -69.9  -21.7
! 17.86 GHz  -10.1  -70.9  -70.8  -13.4
! 18 GHz  -10.5  -70.5  -71.0  -13.1
