!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:33:56 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -66.09 dB at 60 MHz (marker M1); lowest = -74.2 dB at 17.95 GHz (marker M2)
!   lowest |S11| = -54.0 dB at 4.91 GHz (marker M3), VSWR 1.00, Z = 50.1 + j0.185 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (257.5 MHz wide, 1.45 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -47.3 to -11.1 dB; largest |S21 - S12| = 3.7e-05
!   the Smith chart shows 10 MHz to 9.01 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -26.5  -66.3  -66.3  -26.6
! 60 MHz  -27.3  -66.1  -66.1  -28.8
! 1.53 GHz  -28.8  -67.5  -67.5  -16.6
! 3.01 GHz  -26.8  -68.2  -68.1  -21.7
! 4.01 GHz  -29.0  -68.6  -68.6  -19.3
! 4.19 GHz  -30.5  -68.7  -68.7  -19.5
! 4.52 GHz  -34.0  -68.9  -68.9  -17.4
! 4.62 GHz  -34.4  -69.2  -69.1  -19.0
! 4.79 GHz  -30.6  -69.0  -69.0  -19.0
! 4.91 GHz  -54.0  -69.0  -69.0  -20.1
! 5.23 GHz  -31.6  -69.2  -69.2  -26.4
! 5.51 GHz  -36.1  -69.4  -69.3  -41.6
! 6.01 GHz  -25.6  -69.7  -69.7  -21.7
! 9.01 GHz  -15.2  -70.8  -70.9  -11.6
! 10.09 GHz  -27.2  -71.3  -71.5  -12.1
! 10.73 GHz  -19.0  -71.6  -71.9  -12.2
! 12.01 GHz  -53.1  -72.3  -72.4  -14.3
! 12.08 GHz  -20.0  -72.5  -72.2  -14.4
! 12.57 GHz  -24.7  -72.3  -72.4  -16.0
! 15.01 GHz  -15.1  -73.1  -73.4  -21.7
! 17.95 GHz  -14.7  -74.2  -73.8  -13.0
! 18 GHz  -10.7  -73.6  -74.3  -13.1
