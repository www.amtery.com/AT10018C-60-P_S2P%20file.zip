!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:24:51 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -17.49 dB at 10 MHz (marker M1); lowest = -26.8 dB at 17.19 GHz (marker M2)
!   lowest |S11| = -60.3 dB at 12.15 GHz (marker M3), VSWR 1.00, Z = 50 - j0.0961 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (257.7 MHz wide, 1.45 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -39.7 to -9.6 dB; largest |S21 - S12| = 0.0056
!   the Smith chart shows 10.91 GHz to 13.67 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -26.2  -17.5  -17.5  -16.2
! 490 MHz  -27.2  -18.3  -18.3  -26.3
! 3.01 GHz  -26.5  -19.6  -19.6  -20.0
! 3.87 GHz  -33.3  -19.9  -19.9  -25.7
! 4.33 GHz  -27.9  -20.1  -20.1  -16.0
! 4.79 GHz  -30.1  -20.4  -20.4  -34.2
! 4.97 GHz  -34.9  -20.5  -20.4  -21.9
! 5.53 GHz  -34.1  -20.7  -20.7  -31.1
! 6.01 GHz  -25.1  -20.9  -20.9  -23.5
! 6.69 GHz  -21.8  -21.7  -21.7  -13.4
! 7.16 GHz  -21.1  -21.3  -21.3  -39.1
! 7.54 GHz  -23.7  -21.7  -21.8  -15.2
! 9.01 GHz  -14.9  -22.4  -22.4  -12.7
! 12.01 GHz  -43.8  -23.3  -23.4  -15.3
! 12.15 GHz  -60.3  -23.6  -23.5  -16.8
! 13.37 GHz  -14.9  -24.1  -24.2  -17.0
! 13.69 GHz  -16.0  -24.3  -24.3  -28.7
! 14.05 GHz  -13.8  -24.8  -25.0  -15.8
! 15.01 GHz  -15.1  -25.2  -25.3  -16.1
! 15.36 GHz  -14.0  -25.2  -25.2  -30.5
! 17.19 GHz  -11.2  -26.8  -26.8  -11.9
! 18 GHz  -10.8  -26.3  -26.4  -24.0
