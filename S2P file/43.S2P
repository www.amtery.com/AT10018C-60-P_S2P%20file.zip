!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:53:59 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -46.45 dB at 10 MHz (marker M1); lowest = -55.2 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -66.4 dB at 530 MHz (marker M3), VSWR 1.00, Z = 50 + j0.0465 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.86 GHz (251.7 MHz wide, 1.42 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.0002
!   the Smith chart shows 10 MHz to 9.11 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -46.0  -46.5  -46.5  -24.2
! 530 MHz  -66.4  -47.2  -47.2  -22.7
! 860 MHz  -35.4  -47.4  -47.4  -20.2
! 990 MHz  -52.9  -47.4  -47.4  -19.5
! 1.35 GHz  -40.4  -47.5  -47.6  -17.8
! 1.54 GHz  -38.9  -47.7  -47.7  -17.6
! 2.34 GHz  -38.5  -48.1  -48.1  -17.9
! 2.73 GHz  -42.3  -48.2  -48.2  -19.4
! 3.01 GHz  -31.1  -48.3  -48.3  -20.7
! 3.98 GHz  -38.3  -48.7  -48.7  -21.4
! 4.17 GHz  -33.8  -48.8  -48.8  -19.6
! 4.73 GHz  -28.3  -49.2  -49.1  -19.2
! 5.6 GHz  -25.3  -49.7  -49.7  -30.4
! 6.01 GHz  -21.7  -50.0  -50.0  -22.2
! 9.01 GHz  -15.6  -51.7  -51.7  -12.1
! 10.3 GHz  -18.5  -52.1  -52.1  -13.1
! 11.79 GHz  -18.9  -52.3  -52.4  -14.2
! 12.01 GHz  -33.8  -52.3  -52.4  -14.5
! 15.01 GHz  -14.5  -53.6  -53.6  -19.7
! 16.8 GHz  -16.4  -54.7  -54.8  -13.7
! 17.89 GHz  -9.8  -55.2  -55.2  -22.4
! 18 GHz  -10.5  -55.1  -55.2  -18.9
