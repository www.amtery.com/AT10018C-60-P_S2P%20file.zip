!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:26:53 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -15.45 dB at 10 MHz (marker M1); lowest = -24.8 dB at 17.18 GHz (marker M2)
!   lowest |S11| = -54.6 dB at 12.15 GHz (marker M3), VSWR 1.00, Z = 49.9 - j0.152 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.87 GHz (254.5 MHz wide, 1.43 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -59.9 to -9.5 dB; largest |S21 - S12| = 0.007
!   the Smith chart shows 10.91 GHz to 13.67 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -25.4  -15.4  -15.5  -14.2
! 450 MHz  -27.6  -16.3  -16.3  -35.7
! 840 MHz  -24.1  -16.5  -16.5  -17.9
! 3.01 GHz  -26.2  -17.6  -17.7  -21.9
! 4.97 GHz  -34.0  -18.5  -18.5  -23.4
! 5.28 GHz  -32.5  -18.6  -18.6  -21.5
! 5.55 GHz  -34.2  -18.7  -18.7  -37.7
! 6.01 GHz  -25.1  -19.0  -19.0  -22.7
! 6.8 GHz  -26.4  -19.7  -19.7  -14.3
! 7.18 GHz  -20.3  -19.4  -19.4  -41.5
! 7.54 GHz  -23.6  -19.8  -19.9  -14.5
! 9.01 GHz  -14.7  -20.5  -20.5  -12.6
! 12.01 GHz  -43.3  -21.5  -21.5  -15.5
! 12.15 GHz  -54.6  -21.7  -21.6  -16.5
! 13.36 GHz  -14.9  -22.2  -22.3  -17.2
! 13.69 GHz  -16.0  -22.4  -22.4  -27.6
! 14.06 GHz  -13.2  -22.9  -23.1  -16.0
! 15.01 GHz  -15.0  -23.3  -23.4  -16.3
! 15.36 GHz  -13.9  -23.3  -23.3  -31.6
! 16.34 GHz  -13.0  -24.1  -24.2  -13.1
! 17.18 GHz  -10.9  -24.8  -24.8  -12.1
! 18 GHz  -10.7  -24.4  -24.5  -23.7
