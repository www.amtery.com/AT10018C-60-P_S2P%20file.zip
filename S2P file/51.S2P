!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:46:33 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -55.06 dB at 60 MHz (marker M1); lowest = -63.2 dB at 17.9 GHz (marker M2)
!   lowest |S11| = -69.6 dB at 10.97 GHz (marker M3), VSWR 1.00, Z = 50 + j0.000524 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -47.5 to -11.1 dB; largest |S21 - S12| = 9.6e-05
!   the Smith chart shows 9.77 GHz to 12.27 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -22.6  -55.3  -55.3  -26.6
! 60 MHz  -23.8  -55.1  -55.1  -28.8
! 1.53 GHz  -26.9  -56.5  -56.6  -16.6
! 2.38 GHz  -30.6  -57.0  -57.0  -17.9
! 2.63 GHz  -30.4  -57.1  -57.1  -19.1
! 2.79 GHz  -41.3  -57.1  -57.1  -20.7
! 3.01 GHz  -33.2  -57.2  -57.2  -21.7
! 3.47 GHz  -35.4  -57.4  -57.5  -25.9
! 4.14 GHz  -27.3  -57.7  -57.7  -18.5
! 4.72 GHz  -33.2  -58.1  -58.1  -20.2
! 5.22 GHz  -27.5  -58.3  -58.3  -26.2
! 5.51 GHz  -32.6  -58.4  -58.4  -41.8
! 6.01 GHz  -26.8  -58.7  -58.7  -21.6
! 6.5 GHz  -35.2  -59.0  -59.0  -17.9
! 7.26 GHz  -20.8  -59.6  -59.6  -15.9
! 9.01 GHz  -16.6  -60.4  -60.4  -11.6
! 10.31 GHz  -18.4  -60.6  -60.6  -11.9
! 10.97 GHz  -69.6  -61.2  -61.2  -12.5
! 12.01 GHz  -23.8  -61.3  -61.3  -14.3
! 15.01 GHz  -17.6  -61.8  -61.7  -21.7
! 17.9 GHz  -10.8  -63.2  -62.9  -13.8
! 18 GHz  -11.3  -63.0  -63.2  -13.1
