!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:40:37 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -60.06 dB at 60 MHz (marker M1); lowest = -68.1 dB at 17.86 GHz (marker M2)
!   lowest |S11| = -54.3 dB at 5.07 GHz (marker M3), VSWR 1.00, Z = 50.1 + j0.126 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.62 GHz to 17.74 GHz (118.5 MHz wide, 0.67 % of centre); 17.74 GHz to 17.86 GHz (118.9 MHz wide, 0.668 % of centre) (the widest 3 of 4)
!   |S22| runs from -47.6 to -11.1 dB; largest |S21 - S12| = 6e-05
!   the Smith chart shows 10 MHz to 9 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -23.8  -60.3  -60.2  -26.6
! 60 MHz  -24.5  -60.1  -60.1  -28.8
! 1.53 GHz  -26.1  -61.5  -61.5  -16.6
! 3.01 GHz  -26.0  -62.2  -62.2  -21.7
! 4.45 GHz  -27.0  -62.9  -62.9  -20.0
! 5.07 GHz  -54.3  -63.1  -63.1  -22.8
! 5.51 GHz  -36.1  -63.4  -63.4  -41.7
! 6.01 GHz  -26.9  -63.7  -63.8  -21.6
! 7.81 GHz  -20.4  -64.6  -64.6  -15.4
! 9.01 GHz  -14.9  -65.2  -65.2  -11.6
! 10.09 GHz  -25.7  -65.4  -65.6  -12.1
! 10.73 GHz  -18.8  -65.9  -65.9  -12.2
! 10.95 GHz  -32.7  -66.1  -66.2  -12.5
! 12.01 GHz  -38.6  -66.4  -66.2  -14.3
! 12.22 GHz  -20.4  -66.6  -66.3  -14.8
! 13.14 GHz  -21.3  -66.4  -66.4  -17.4
! 14.55 GHz  -16.0  -66.6  -66.6  -22.8
! 15.01 GHz  -15.1  -67.0  -67.0  -21.7
! 15.95 GHz  -13.8  -67.2  -67.4  -17.9
! 17.12 GHz  -14.6  -67.4  -67.3  -18.0
! 17.86 GHz  -10.1  -68.1  -67.9  -13.4
! 18 GHz  -10.4  -67.9  -68.2  -13.1
