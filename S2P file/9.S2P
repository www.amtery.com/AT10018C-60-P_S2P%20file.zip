!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:30:11 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -12.37 dB at 10 MHz (marker M1); lowest = -21.7 dB at 17.18 GHz (marker M2)
!   lowest |S11| = -65.5 dB at 400 MHz (marker M3), VSWR 1.00, Z = 50 + j0.0482 ohm
!   |S11| at or under -10 dB: start of sweep to 17.45 GHz; 17.48 GHz to 17.59 GHz (108.2 MHz wide, 0.617 % of centre); 17.62 GHz to 17.87 GHz (248.7 MHz wide, 1.4 % of centre) (the widest 3 of 4)
!   |S22| runs from -55.1 to -9.5 dB; largest |S21 - S12| = 0.01
!   the Smith chart shows 10 MHz to 8.44 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -33.7  -12.4  -12.4  -13.4
! 400 MHz  -65.5  -13.3  -13.3  -33.1
! 820 MHz  -32.1  -13.4  -13.4  -17.2
! 1.23 GHz  -42.2  -13.7  -13.7  -29.4
! 1.67 GHz  -32.9  -13.9  -13.9  -15.7
! 3.01 GHz  -31.3  -14.6  -14.6  -22.2
! 4.32 GHz  -38.2  -15.2  -15.2  -17.4
! 4.79 GHz  -38.0  -15.4  -15.4  -27.2
! 5.26 GHz  -24.4  -15.5  -15.5  -21.5
! 5.56 GHz  -26.8  -15.7  -15.7  -37.2
! 6.01 GHz  -21.7  -16.0  -16.0  -22.2
! 6.8 GHz  -23.3  -16.7  -16.7  -14.2
! 7.18 GHz  -19.5  -16.3  -16.3  -39.2
! 7.53 GHz  -23.4  -16.7  -16.8  -14.7
! 9.01 GHz  -15.1  -17.4  -17.4  -12.6
! 12.01 GHz  -33.6  -18.4  -18.4  -15.6
! 13.36 GHz  -14.1  -19.2  -19.2  -17.0
! 13.68 GHz  -14.6  -19.4  -19.3  -29.5
! 15.01 GHz  -14.5  -20.3  -20.3  -16.4
! 15.35 GHz  -13.3  -20.2  -20.2  -32.2
! 17.18 GHz  -10.5  -21.7  -21.7  -12.1
! 18 GHz  -10.6  -21.4  -21.4  -24.2
