!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:44:05 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -57.08 dB at 60 MHz (marker M1); lowest = -65.3 dB at 17.91 GHz (marker M2)
!   lowest |S11| = -52.8 dB at 4.73 GHz (marker M3), VSWR 1.00, Z = 49.8 - j0.133 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -47.5 to -11.1 dB; largest |S21 - S12| = 7.6e-05
!   the Smith chart shows 10 MHz to 9 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -23.9  -57.3  -57.3  -26.6
! 60 MHz  -24.9  -57.1  -57.1  -28.8
! 1.53 GHz  -27.7  -58.6  -58.6  -16.6
! 2.38 GHz  -30.5  -59.1  -59.1  -17.9
! 2.79 GHz  -34.8  -59.1  -59.1  -20.7
! 3.01 GHz  -30.1  -59.3  -59.3  -21.7
! 3.34 GHz  -33.5  -59.5  -59.5  -25.9
! 4.04 GHz  -29.0  -59.7  -59.8  -19.3
! 4.55 GHz  -32.0  -60.0  -60.0  -18.2
! 4.73 GHz  -52.8  -60.1  -60.1  -20.0
! 5.22 GHz  -28.8  -60.3  -60.3  -26.2
! 5.5 GHz  -34.9  -60.5  -60.5  -40.1
! 6.01 GHz  -26.2  -60.8  -60.8  -21.6
! 6.51 GHz  -32.1  -61.1  -61.0  -18.0
! 7.8 GHz  -21.4  -61.8  -61.8  -15.6
! 9.01 GHz  -16.4  -62.3  -62.4  -11.6
! 9.51 GHz  -23.4  -62.4  -62.4  -11.2
! 10.61 GHz  -20.6  -62.7  -62.8  -12.2
! 12.01 GHz  -27.0  -63.4  -63.4  -14.3
! 15.01 GHz  -16.7  -63.9  -63.9  -21.7
! 17.91 GHz  -12.2  -65.3  -65.3  -13.8
! 18 GHz  -11.6  -65.0  -65.3  -13.1
