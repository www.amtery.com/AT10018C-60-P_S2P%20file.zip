!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:25:56 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -16.42 dB at 10 MHz (marker M1); lowest = -25.6 dB at 17.18 GHz (marker M2)
!   lowest |S11| = -69.2 dB at 300 MHz (marker M3), VSWR 1.00, Z = 50 + j0.0227 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (250 MHz wide, 1.41 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -59.7 to -9.5 dB; largest |S21 - S12| = 0.0063
!   the Smith chart shows 10 MHz to 8.55 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -44.8  -16.4  -16.4  -14.3
! 300 MHz  -69.2  -17.2  -17.2  -22.4
! 460 MHz  -44.9  -17.3  -17.3  -34.4
! 860 MHz  -34.9  -17.5  -17.5  -18.0
! 3.01 GHz  -31.5  -18.6  -18.6  -21.9
! 4.32 GHz  -40.0  -19.1  -19.2  -17.0
! 4.78 GHz  -32.8  -19.4  -19.4  -28.1
! 5.25 GHz  -23.3  -19.5  -19.5  -21.3
! 5.55 GHz  -25.3  -19.7  -19.7  -37.8
! 6.01 GHz  -21.3  -20.0  -20.0  -22.8
! 6.8 GHz  -23.3  -20.6  -20.6  -14.3
! 7.18 GHz  -19.2  -20.3  -20.3  -41.8
! 7.54 GHz  -22.1  -20.7  -20.8  -14.6
! 9.01 GHz  -15.5  -21.4  -21.4  -12.6
! 12.01 GHz  -31.8  -22.3  -22.4  -15.5
! 13.69 GHz  -15.3  -23.3  -23.3  -27.7
! 14.06 GHz  -12.5  -23.8  -23.9  -16.0
! 15.01 GHz  -14.4  -24.2  -24.2  -16.3
! 15.36 GHz  -13.7  -24.1  -24.1  -31.7
! 16.34 GHz  -12.8  -24.9  -25.0  -13.1
! 17.18 GHz  -10.8  -25.6  -25.7  -12.1
! 18 GHz  -10.5  -25.3  -25.3  -23.7
