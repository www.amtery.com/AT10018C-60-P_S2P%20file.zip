!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:57:57 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -42.48 dB at 10 MHz (marker M1); lowest = -51.4 dB at 17.87 GHz (marker M2)
!   lowest |S11| = -56.3 dB at 4.44 GHz (marker M3), VSWR 1.00, Z = 49.9 + j0.0984 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -36.2 to -11.4 dB; largest |S21 - S12| = 0.0003
!   the Smith chart shows 10 MHz to 9.1 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -27.6  -42.5  -42.5  -24.3
! 1.72 GHz  -30.0  -43.8  -43.8  -17.4
! 2.38 GHz  -34.5  -44.1  -44.1  -18.1
! 2.79 GHz  -39.2  -44.3  -44.3  -19.9
! 3.01 GHz  -31.6  -44.4  -44.4  -20.7
! 3.44 GHz  -38.5  -44.5  -44.6  -25.5
! 3.62 GHz  -33.1  -44.6  -44.7  -24.8
! 3.94 GHz  -40.2  -44.8  -44.8  -21.8
! 4.13 GHz  -30.4  -44.9  -44.9  -19.4
! 4.44 GHz  -56.3  -45.1  -45.1  -19.1
! 5.09 GHz  -31.2  -45.4  -45.4  -21.4
! 5.6 GHz  -31.7  -45.8  -45.8  -30.4
! 6.01 GHz  -24.9  -46.1  -46.1  -22.2
! 9.01 GHz  -16.5  -47.9  -47.9  -12.1
! 10.46 GHz  -18.1  -48.4  -48.4  -14.0
! 10.97 GHz  -35.0  -48.4  -48.4  -14.3
! 11.33 GHz  -19.3  -48.5  -48.5  -14.2
! 12.01 GHz  -27.5  -48.6  -48.6  -14.5
! 15.01 GHz  -16.6  -49.8  -49.8  -19.7
! 16.8 GHz  -20.9  -50.9  -51.0  -13.7
! 17.87 GHz  -11.3  -51.4  -51.4  -22.0
! 18 GHz  -12.1  -51.3  -51.4  -18.9
