!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:15:55 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -25.31 dB at 10 MHz (marker M1); lowest = -35.4 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -43.0 dB at 5.88 GHz (marker M3), VSWR 1.01, Z = 49.3 - j0.0661 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -35.6 to -10.4 dB; largest |S21 - S12| = 0.0023
!   the Smith chart shows 10 MHz to 9.08 GHz only
!   S11 on the Smith chart (normalised r, x): 10 MHz: 1.22, -0.01; 5.47 GHz: 0.94, -0.01; 9.08 GHz: 1.19, +0.05
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -19.9  -25.3  -25.3  -24.3
! 1.98 GHz  -22.4  -26.8  -26.8  -17.7
! 3.01 GHz  -24.7  -27.3  -27.3  -18.8
! 4.02 GHz  -22.8  -27.8  -27.8  -23.7
! 4.85 GHz  -26.4  -28.1  -28.1  -19.9
! 5.47 GHz  -30.4  -28.3  -28.3  -24.7
! 5.74 GHz  -32.7  -28.5  -28.5  -29.7
! 5.88 GHz  -43.0  -28.6  -28.6  -27.2
! 6.01 GHz  -39.5  -28.7  -28.8  -23.5
! 6.67 GHz  -26.6  -29.4  -29.3  -16.9
! 9.01 GHz  -15.4  -30.5  -30.5  -14.6
! 9.08 GHz  -20.8  -30.4  -30.4  -15.7
! 10.1 GHz  -25.4  -30.9  -30.9  -11.3
! 12.01 GHz  -24.4  -31.3  -31.4  -15.2
! 12.91 GHz  -18.3  -32.0  -32.1  -16.3
! 13.86 GHz  -22.4  -32.4  -32.7  -21.3
! 15.01 GHz  -19.9  -32.8  -32.8  -15.1
! 15.8 GHz  -16.8  -33.2  -33.0  -20.3
! 16.26 GHz  -22.6  -33.3  -33.4  -25.7
! 16.95 GHz  -23.1  -34.0  -34.1  -14.3
! 17.89 GHz  -12.0  -35.4  -35.4  -11.5
! 18 GHz  -13.1  -35.3  -35.4  -12.0
