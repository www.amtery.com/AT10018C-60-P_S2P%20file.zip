!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:55:59 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -44.43 dB at 10 MHz (marker M1); lowest = -53.2 dB at 17.87 GHz (marker M2)
!   lowest |S11| = -64.0 dB at 3.33 GHz (marker M3), VSWR 1.00, Z = 50 + j0.0547 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.62 GHz to 17.73 GHz (118.2 MHz wide, 0.668 % of centre); 17.74 GHz to 17.86 GHz (115.8 MHz wide, 0.65 % of centre) (the widest 3 of 4)
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.00025
!   the Smith chart shows 10 MHz to 9.1 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -37.3  -44.4  -44.4  -24.2
! 480 MHz  -39.5  -45.2  -45.2  -23.0
! 850 MHz  -32.2  -45.4  -45.4  -20.3
! 1.01 GHz  -44.5  -45.4  -45.4  -19.5
! 1.21 GHz  -46.0  -45.5  -45.5  -18.4
! 2.35 GHz  -37.7  -46.1  -46.1  -17.9
! 2.75 GHz  -41.8  -46.3  -46.3  -19.3
! 3.01 GHz  -30.3  -46.4  -46.4  -20.7
! 3.33 GHz  -64.0  -46.5  -46.5  -25.2
! 3.61 GHz  -33.3  -46.7  -46.7  -25.4
! 3.79 GHz  -43.2  -46.7  -46.7  -22.6
! 4.17 GHz  -34.8  -46.9  -46.9  -19.6
! 4.73 GHz  -29.3  -47.2  -47.2  -19.2
! 5.6 GHz  -26.0  -47.7  -47.7  -30.4
! 6.01 GHz  -21.9  -48.0  -48.1  -22.2
! 9.01 GHz  -15.2  -49.8  -49.8  -12.1
! 10.59 GHz  -19.5  -50.2  -50.3  -14.2
! 12.01 GHz  -34.8  -50.4  -50.4  -14.5
! 15.01 GHz  -14.3  -51.6  -51.7  -19.7
! 16.8 GHz  -16.2  -52.8  -52.9  -13.7
! 17.87 GHz  -9.6  -53.2  -53.2  -22.0
! 18 GHz  -10.3  -53.1  -53.2  -18.9
