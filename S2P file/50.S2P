!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:47:44 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -54.03 dB at 60 MHz (marker M1); lowest = -62.3 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -51.4 dB at 12.7 GHz (marker M3), VSWR 1.01, Z = 50 - j0.267 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -47.6 to -11.1 dB; largest |S21 - S12| = 0.0001
!   the Smith chart shows 11.32 GHz to 14.18 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.0  -54.2  -54.2  -26.6
! 60 MHz  -17.7  -54.0  -54.0  -28.8
! 1.53 GHz  -20.0  -55.5  -55.6  -16.6
! 3.01 GHz  -25.0  -56.2  -56.2  -21.7
! 4.72 GHz  -23.5  -57.1  -57.1  -20.2
! 5.22 GHz  -26.7  -57.3  -57.3  -26.2
! 5.32 GHz  -26.5  -57.3  -57.3  -28.8
! 5.51 GHz  -29.1  -57.5  -57.5  -41.8
! 6.01 GHz  -31.6  -57.7  -57.7  -21.6
! 7.13 GHz  -19.3  -58.4  -58.5  -16.2
! 8.31 GHz  -17.8  -59.2  -59.3  -14.9
! 9.01 GHz  -14.9  -59.5  -59.5  -11.6
! 12.01 GHz  -20.0  -60.4  -60.5  -14.3
! 12.7 GHz  -51.4  -60.5  -60.5  -16.4
! 13 GHz  -27.4  -60.3  -60.5  -17.3
! 13.5 GHz  -22.9  -60.7  -60.8  -19.1
! 13.87 GHz  -32.0  -60.2  -60.6  -20.1
! 15.01 GHz  -18.4  -60.6  -60.8  -21.7
! 15.95 GHz  -14.9  -61.4  -61.5  -17.9
! 17.12 GHz  -17.9  -61.5  -61.4  -18.0
! 17.88 GHz  -10.5  -62.3  -62.3  -13.6
! 18 GHz  -11.7  -62.2  -62.4  -13.1
