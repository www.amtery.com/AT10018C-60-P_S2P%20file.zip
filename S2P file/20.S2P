!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:18:14 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -23.28 dB at 10 MHz (marker M1); lowest = -33.5 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -46.3 dB at 11.54 GHz (marker M3), VSWR 1.01, Z = 50.5 - j0.0743 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -35.5 to -10.4 dB; largest |S21 - S12| = 0.0028
!   the Smith chart shows 10.35 GHz to 12.93 GHz only
!   S11 on the Smith chart (normalised r, x): 10.35 GHz: 1.26, +0.14; 10.83 GHz: 1.08, -0.11; 12.93 GHz: 0.97, +0.21
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.8  -23.3  -23.3  -24.1
! 1.97 GHz  -20.7  -24.8  -24.8  -17.8
! 3.01 GHz  -23.6  -25.4  -25.4  -18.8
! 3.78 GHz  -22.0  -25.8  -25.8  -24.9
! 4.98 GHz  -27.6  -26.2  -26.2  -20.0
! 5.33 GHz  -29.4  -26.3  -26.3  -22.5
! 5.74 GHz  -29.0  -26.6  -26.6  -29.6
! 6.01 GHz  -30.5  -26.8  -26.8  -23.6
! 6.55 GHz  -24.7  -27.3  -27.2  -17.2
! 9.01 GHz  -14.3  -28.5  -28.6  -14.5
! 10.35 GHz  -17.7  -29.0  -29.1  -11.4
! 10.83 GHz  -23.7  -29.0  -29.0  -12.7
! 11.54 GHz  -46.3  -29.2  -29.2  -13.9
! 12.01 GHz  -25.6  -29.4  -29.5  -15.2
! 12.93 GHz  -19.6  -30.1  -30.1  -16.2
! 13.86 GHz  -21.6  -30.5  -30.8  -21.3
! 15.01 GHz  -19.5  -30.9  -30.9  -15.1
! 15.8 GHz  -15.6  -31.3  -31.1  -20.3
! 16.26 GHz  -20.7  -31.4  -31.4  -25.7
! 16.95 GHz  -21.7  -32.1  -32.2  -14.3
! 17.88 GHz  -11.3  -33.5  -33.5  -11.4
! 18 GHz  -12.5  -33.4  -33.5  -12.1
