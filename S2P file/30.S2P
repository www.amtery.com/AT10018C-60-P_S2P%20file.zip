!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:07:43 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -33.33 dB at 10 MHz (marker M1); lowest = -43.2 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -58.8 dB at 4.89 GHz (marker M3), VSWR 1.00, Z = 50 - j0.111 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (258.8 MHz wide, 1.46 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -35.7 to -10.4 dB; largest |S21 - S12| = 0.00092
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -26.6  -33.3  -33.3  -24.3
! 3.01 GHz  -26.8  -35.2  -35.2  -18.8
! 3.78 GHz  -28.6  -35.6  -35.6  -24.8
! 4.78 GHz  -30.2  -36.0  -36.0  -18.8
! 4.89 GHz  -58.8  -36.0  -36.0  -19.3
! 4.97 GHz  -35.7  -36.1  -36.0  -20.0
! 5.42 GHz  -26.5  -36.2  -36.2  -24.0
! 5.74 GHz  -30.5  -36.4  -36.4  -29.8
! 6.01 GHz  -25.7  -36.7  -36.7  -23.5
! 6.56 GHz  -21.9  -37.2  -37.2  -17.2
! 9.01 GHz  -14.9  -38.3  -38.3  -14.6
! 10.22 GHz  -25.6  -38.7  -38.8  -11.2
! 10.73 GHz  -18.3  -38.7  -38.7  -12.3
! 12.01 GHz  -43.2  -39.0  -39.1  -15.2
! 12.08 GHz  -20.2  -39.2  -39.2  -15.4
! 12.57 GHz  -24.9  -39.6  -39.6  -16.4
! 13.86 GHz  -18.3  -40.2  -40.5  -21.3
! 15.01 GHz  -15.1  -40.6  -40.7  -15.1
! 16.26 GHz  -17.1  -41.0  -41.1  -25.7
! 16.95 GHz  -16.6  -41.8  -41.8  -14.3
! 17.88 GHz  -9.8  -43.2  -43.2  -11.4
! 18 GHz  -10.7  -43.0  -43.1  -12.1
