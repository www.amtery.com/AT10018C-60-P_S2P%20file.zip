!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:01:11 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -39.44 dB at 10 MHz (marker M1); lowest = -48.6 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -47.1 dB at 12.13 GHz (marker M3), VSWR 1.01, Z = 49.6 - j0.0601 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -36.2 to -11.4 dB; largest |S21 - S12| = 0.00042
!   the Smith chart shows 10.89 GHz to 13.66 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.9  -39.4  -39.4  -24.2
! 1.72 GHz  -20.0  -40.8  -40.8  -17.4
! 3.01 GHz  -22.0  -41.5  -41.5  -20.7
! 3.53 GHz  -23.2  -41.7  -41.7  -23.2
! 4.73 GHz  -26.5  -42.3  -42.3  -19.2
! 5.11 GHz  -25.7  -42.5  -42.4  -21.7
! 5.31 GHz  -25.5  -42.6  -42.6  -25.0
! 5.6 GHz  -27.4  -42.8  -42.8  -30.4
! 6.01 GHz  -27.7  -43.2  -43.2  -22.2
! 6.89 GHz  -22.6  -43.6  -43.6  -18.4
! 7.96 GHz  -18.1  -44.3  -44.3  -13.5
! 9.01 GHz  -14.9  -45.1  -45.1  -12.1
! 10.67 GHz  -24.9  -45.6  -45.7  -14.1
! 11.61 GHz  -19.0  -45.7  -45.8  -14.1
! 12.01 GHz  -27.1  -45.7  -45.8  -14.5
! 12.06 GHz  -20.3  -45.9  -45.9  -14.6
! 12.13 GHz  -47.1  -46.0  -45.9  -14.7
! 15.01 GHz  -17.3  -47.0  -47.0  -19.7
! 16.8 GHz  -20.1  -48.1  -48.2  -13.7
! 17.72 GHz  -12.6  -48.4  -48.4  -23.7
! 17.89 GHz  -11.1  -48.6  -48.6  -22.4
! 18 GHz  -12.1  -48.5  -48.6  -18.9
