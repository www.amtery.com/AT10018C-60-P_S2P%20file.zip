!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:20:17 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -21.28 dB at 10 MHz (marker M1); lowest = -31.5 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -42.7 dB at 12.69 GHz (marker M3), VSWR 1.01, Z = 50.7 - j0.0814 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -35.4 to -10.4 dB; largest |S21 - S12| = 0.0036
!   the Smith chart shows 11.33 GHz to 14.16 GHz only
!   S11 on the Smith chart (normalised r, x): 11.33 GHz: 1.29, +0.11; 12.99 GHz: 1.02, -0.10; 14.16 GHz: 1.02, +0.16
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.1  -21.3  -21.3  -24.2
! 3.01 GHz  -26.8  -23.4  -23.4  -18.8
! 3.78 GHz  -21.6  -23.7  -23.7  -24.8
! 4.98 GHz  -26.9  -24.2  -24.1  -20.0
! 5.74 GHz  -23.8  -24.5  -24.5  -29.7
! 6.01 GHz  -25.2  -24.7  -24.7  -23.6
! 6.55 GHz  -24.6  -25.2  -25.2  -17.2
! 7.61 GHz  -22.3  -25.7  -25.7  -16.6
! 8.4 GHz  -16.8  -26.2  -26.3  -12.3
! 9.01 GHz  -14.2  -26.5  -26.5  -14.5
! 11.33 GHz  -17.3  -27.1  -27.1  -14.1
! 12.01 GHz  -21.3  -27.3  -27.4  -15.2
! 12.69 GHz  -42.7  -27.8  -27.9  -16.4
! 12.99 GHz  -25.8  -28.0  -28.0  -16.7
! 13.23 GHz  -23.2  -28.1  -28.2  -17.2
! 14.16 GHz  -21.7  -28.5  -28.6  -18.2
! 15.01 GHz  -20.9  -28.7  -28.8  -15.1
! 15.8 GHz  -14.2  -29.2  -29.1  -20.3
! 16.26 GHz  -19.9  -29.3  -29.4  -25.7
! 16.95 GHz  -20.0  -30.1  -30.1  -14.3
! 17.89 GHz  -10.7  -31.5  -31.5  -11.5
! 18 GHz  -12.0  -31.4  -31.5  -12.1
