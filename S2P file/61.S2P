!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:34:54 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -65.08 dB at 60 MHz (marker M1); lowest = -73.1 dB at 17.78 GHz (marker M2)
!   lowest |S11| = -62.7 dB at 520 MHz (marker M3), VSWR 1.00, Z = 50 + j0.0689 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (249 MHz wide, 1.4 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -47.0 to -11.1 dB; largest |S21 - S12| = 4.5e-05
!   the Smith chart shows 10 MHz to 9.01 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -49.0  -65.3  -65.3  -26.6
! 60 MHz  -50.9  -65.1  -65.1  -28.8
! 520 MHz  -62.7  -66.0  -66.1  -22.8
! 860 MHz  -35.5  -66.2  -66.2  -19.4
! 1.35 GHz  -40.1  -66.4  -66.4  -16.8
! 1.54 GHz  -39.0  -66.6  -66.6  -16.6
! 2.34 GHz  -39.2  -67.0  -67.0  -17.7
! 2.74 GHz  -40.1  -67.1  -67.0  -19.9
! 3.01 GHz  -31.1  -67.2  -67.2  -21.7
! 3.61 GHz  -32.0  -67.5  -67.5  -24.0
! 3.79 GHz  -45.2  -67.5  -67.5  -20.9
! 4.17 GHz  -35.4  -67.7  -67.7  -19.0
! 4.72 GHz  -28.0  -68.2  -68.2  -20.2
! 5.22 GHz  -24.0  -68.2  -68.2  -26.2
! 5.51 GHz  -26.4  -68.4  -68.3  -41.4
! 6.01 GHz  -21.7  -68.7  -68.8  -21.7
! 9.01 GHz  -15.8  -69.8  -69.8  -11.6
! 11.35 GHz  -21.9  -71.3  -71.3  -13.1
! 12.01 GHz  -30.4  -70.9  -71.4  -14.3
! 15.01 GHz  -14.4  -71.8  -72.0  -21.7
! 17.78 GHz  -12.6  -73.1  -72.9  -14.4
! 18 GHz  -10.4  -72.6  -72.9  -13.1
