!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:45:12 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -56.06 dB at 60 MHz (marker M1); lowest = -64.4 dB at 17.96 GHz (marker M2)
!   lowest |S11| = -55.7 dB at 6.21 GHz (marker M3), VSWR 1.00, Z = 50 - j0.156 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -47.6 to -11.1 dB; largest |S21 - S12| = 8.9e-05
!   the Smith chart shows 10 MHz to 8.98 GHz only
!   S11 on the Smith chart (normalised r, x): 10 MHz: 1.30, -0.01; 3.19 GHz: 0.92, -0.15; 8.98 GHz: 1.25, -0.09
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.8  -56.3  -56.3  -26.6
! 60 MHz  -18.4  -56.1  -56.1  -28.8
! 1.53 GHz  -20.2  -57.6  -57.6  -16.6
! 3.01 GHz  -22.9  -58.3  -58.3  -21.7
! 3.19 GHz  -21.1  -58.5  -58.5  -25.2
! 4.72 GHz  -25.5  -59.1  -59.1  -20.2
! 5.22 GHz  -30.5  -59.3  -59.3  -26.2
! 5.31 GHz  -28.4  -59.4  -59.4  -28.2
! 5.51 GHz  -31.0  -59.5  -59.5  -41.8
! 5.92 GHz  -39.2  -59.8  -59.8  -22.4
! 6.01 GHz  -42.9  -59.8  -59.9  -21.6
! 6.21 GHz  -55.7  -59.9  -59.9  -19.8
! 7.12 GHz  -20.5  -60.4  -60.5  -16.3
! 8.98 GHz  -18.5  -61.4  -61.5  -12.1
! 9.01 GHz  -15.2  -61.5  -61.6  -11.6
! 10.89 GHz  -17.4  -62.4  -62.5  -12.3
! 11.1 GHz  -29.3  -62.5  -62.6  -12.6
! 12.01 GHz  -24.5  -62.5  -62.5  -14.3
! 15.01 GHz  -18.3  -62.8  -63.0  -21.7
! 17.12 GHz  -17.8  -63.5  -63.6  -18.0
! 17.96 GHz  -17.0  -64.4  -64.2  -12.8
! 18 GHz  -12.1  -64.2  -64.4  -13.1
