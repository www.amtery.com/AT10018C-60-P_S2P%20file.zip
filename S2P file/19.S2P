!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:19:15 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -22.30 dB at 10 MHz (marker M1); lowest = -32.4 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -62.3 dB at 4.77 GHz (marker M3), VSWR 1.00, Z = 49.9 - j0.0438 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -35.5 to -10.4 dB; largest |S21 - S12| = 0.0033
!   the Smith chart shows 10 MHz to 9.07 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -22.6  -22.3  -22.3  -24.2
! 2.36 GHz  -30.3  -24.0  -24.1  -17.3
! 2.77 GHz  -41.1  -24.2  -24.2  -17.8
! 3.01 GHz  -36.5  -24.3  -24.3  -18.8
! 4.03 GHz  -27.2  -24.8  -24.8  -23.6
! 4.77 GHz  -62.3  -25.1  -25.1  -19.0
! 5.28 GHz  -28.1  -25.2  -25.2  -21.8
! 5.74 GHz  -29.1  -25.5  -25.5  -29.7
! 6.01 GHz  -37.1  -25.7  -25.7  -23.6
! 6.94 GHz  -23.7  -26.4  -26.4  -16.9
! 7.6 GHz  -22.8  -26.6  -26.7  -16.6
! 8.4 GHz  -19.0  -27.2  -27.2  -12.3
! 9.01 GHz  -15.1  -27.4  -27.4  -14.6
! 9.6 GHz  -18.5  -27.6  -27.6  -13.9
! 12.01 GHz  -24.9  -28.2  -28.3  -15.2
! 12.91 GHz  -19.1  -28.9  -29.0  -16.3
! 13.86 GHz  -20.8  -29.3  -29.6  -21.3
! 15.01 GHz  -19.2  -29.7  -29.7  -15.1
! 16.26 GHz  -19.3  -30.1  -30.2  -25.7
! 16.95 GHz  -20.2  -30.9  -31.0  -14.3
! 17.89 GHz  -10.7  -32.4  -32.4  -11.5
! 18 GHz  -11.7  -32.2  -32.3  -12.1
