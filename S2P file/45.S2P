!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:51:48 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -48.45 dB at 10 MHz (marker M1); lowest = -57.2 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -65.0 dB at 510 MHz (marker M3), VSWR 1.00, Z = 50 - j0.0469 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (250.1 MHz wide, 1.41 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.00016
!   the Smith chart shows 10 MHz to 9.11 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -50.4  -48.4  -48.5  -24.2
! 510 MHz  -65.0  -49.2  -49.2  -22.8
! 860 MHz  -36.0  -49.4  -49.4  -20.2
! 1.35 GHz  -40.0  -49.6  -49.6  -17.8
! 1.54 GHz  -39.1  -49.7  -49.7  -17.6
! 2.34 GHz  -38.7  -50.1  -50.1  -17.9
! 2.74 GHz  -41.6  -50.2  -50.3  -19.3
! 3.01 GHz  -31.1  -50.4  -50.4  -20.7
! 3.61 GHz  -32.9  -50.6  -50.7  -25.4
! 3.79 GHz  -42.5  -50.7  -50.7  -22.6
! 4.17 GHz  -34.2  -50.9  -50.9  -19.6
! 4.73 GHz  -27.9  -51.2  -51.2  -19.2
! 5.6 GHz  -24.8  -51.7  -51.7  -30.4
! 6.01 GHz  -21.4  -52.0  -52.1  -22.2
! 9.01 GHz  -15.5  -53.8  -53.8  -12.1
! 10.59 GHz  -20.0  -54.2  -54.3  -14.2
! 11.64 GHz  -20.8  -54.3  -54.4  -14.2
! 12.01 GHz  -32.4  -54.3  -54.4  -14.5
! 15.01 GHz  -14.3  -55.6  -55.7  -19.7
! 16.8 GHz  -16.2  -56.7  -56.8  -13.7
! 17.89 GHz  -9.8  -57.2  -57.2  -22.4
! 18 GHz  -10.4  -57.1  -57.2  -18.9
