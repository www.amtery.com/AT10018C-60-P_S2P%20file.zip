!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:00:06 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -40.46 dB at 10 MHz (marker M1); lowest = -49.5 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -52.9 dB at 5.5 GHz (marker M3), VSWR 1.00, Z = 50 + j0.227 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -36.2 to -11.4 dB; largest |S21 - S12| = 0.00038
!   the Smith chart shows 10 MHz to 9.1 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -24.0  -40.5  -40.5  -24.2
! 1.72 GHz  -26.4  -41.8  -41.8  -17.4
! 3.01 GHz  -28.6  -42.4  -42.4  -20.7
! 3.33 GHz  -33.8  -42.6  -42.6  -25.2
! 3.52 GHz  -34.5  -42.7  -42.7  -23.3
! 3.93 GHz  -39.7  -42.9  -42.9  -21.6
! 4.05 GHz  -30.3  -42.9  -42.9  -20.5
! 4.57 GHz  -31.4  -43.2  -43.2  -18.7
! 4.73 GHz  -41.3  -43.3  -43.3  -19.2
! 5.39 GHz  -29.0  -43.7  -43.7  -28.4
! 5.5 GHz  -52.9  -43.7  -43.7  -32.8
! 6.01 GHz  -25.2  -44.2  -44.2  -22.2
! 7.6 GHz  -20.4  -44.9  -44.9  -14.7
! 8.39 GHz  -19.0  -45.5  -45.5  -13.0
! 9.01 GHz  -15.8  -46.0  -46.0  -12.1
! 10.97 GHz  -31.1  -46.5  -46.5  -14.3
! 11.33 GHz  -20.1  -46.6  -46.6  -14.2
! 12.01 GHz  -30.2  -46.6  -46.7  -14.5
! 15.01 GHz  -16.0  -47.8  -47.9  -19.7
! 16.8 GHz  -20.2  -49.0  -49.1  -13.7
! 17.89 GHz  -10.8  -49.5  -49.5  -22.4
! 18 GHz  -11.6  -49.4  -49.5  -18.9
