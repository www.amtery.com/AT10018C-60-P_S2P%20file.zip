!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:05:17 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -35.32 dB at 10 MHz (marker M1); lowest = -44.7 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -46.4 dB at 13.14 GHz (marker M3), VSWR 1.01, Z = 49.5 - j0.0387 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.63 GHz to 17.73 GHz (95.25 MHz wide, 0.539 % of centre); 17.76 GHz to 17.86 GHz (91.78 MHz wide, 0.515 % of centre) (the widest 3 of 4)
!   |S22| runs from -36.0 to -11.4 dB; largest |S21 - S12| = 0.0007
!   the Smith chart shows 11.77 GHz to 14.65 GHz only
!   S11 on the Smith chart (normalised r, x): 11.77 GHz: 1.17, +0.05; 14.05 GHz: 0.89, +0.22; 14.65 GHz: 0.77, +0.40
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -13.5  -35.3  -35.3  -24.2
! 1.72 GHz  -16.3  -36.8  -36.8  -17.4
! 3.01 GHz  -19.9  -37.5  -37.5  -20.7
! 3.53 GHz  -22.4  -37.7  -37.8  -23.2
! 4.73 GHz  -20.8  -38.3  -38.3  -19.2
! 5.6 GHz  -19.6  -38.8  -38.8  -30.5
! 6.01 GHz  -21.6  -39.2  -39.2  -22.2
! 6.9 GHz  -23.3  -39.6  -39.5  -18.5
! 7.96 GHz  -13.8  -40.3  -40.3  -13.5
! 9.01 GHz  -13.4  -41.1  -41.1  -12.1
! 9.6 GHz  -16.1  -41.5  -41.5  -11.9
! 10.95 GHz  -22.3  -41.6  -41.6  -14.4
! 11.77 GHz  -21.6  -41.7  -41.8  -14.3
! 12.01 GHz  -23.8  -41.7  -41.8  -14.5
! 13.14 GHz  -46.4  -42.0  -42.1  -18.1
! 13.52 GHz  -22.8  -42.2  -42.2  -18.4
! 14.05 GHz  -17.8  -42.5  -42.6  -17.3
! 14.65 GHz  -12.0  -42.8  -42.9  -18.5
! 15.01 GHz  -14.7  -43.0  -43.0  -19.7
! 16.8 GHz  -16.3  -44.2  -44.2  -13.7
! 17.88 GHz  -9.0  -44.7  -44.7  -22.2
! 18 GHz  -9.9  -44.6  -44.7  -18.9
