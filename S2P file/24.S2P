!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:13:34 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -27.27 dB at 10 MHz (marker M1); lowest = -37.4 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -56.7 dB at 4.9 GHz (marker M3), VSWR 1.00, Z = 49.9 + j0.0954 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.62 GHz to 17.86 GHz (249.2 MHz wide, 1.4 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -35.5 to -10.4 dB; largest |S21 - S12| = 0.0018
!   the Smith chart shows 10 MHz to 9.08 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -23.8  -27.3  -27.3  -24.1
! 3.01 GHz  -26.5  -29.4  -29.4  -18.9
! 3.78 GHz  -27.3  -29.7  -29.7  -24.9
! 4.51 GHz  -30.7  -30.1  -30.1  -19.4
! 4.62 GHz  -34.4  -30.1  -30.1  -20.3
! 4.78 GHz  -29.5  -30.1  -30.1  -18.8
! 4.9 GHz  -56.7  -30.1  -30.1  -19.1
! 5.41 GHz  -27.7  -30.3  -30.3  -24.1
! 5.56 GHz  -39.4  -30.3  -30.3  -27.6
! 5.74 GHz  -34.7  -30.5  -30.5  -29.6
! 6.01 GHz  -28.2  -30.7  -30.7  -23.6
! 6.55 GHz  -22.9  -31.2  -31.2  -17.2
! 9.01 GHz  -14.3  -32.4  -32.4  -14.6
! 10.22 GHz  -24.1  -32.8  -32.9  -11.2
! 11.31 GHz  -21.9  -32.9  -32.9  -14.0
! 12.01 GHz  -37.7  -33.1  -33.2  -15.2
! 13.86 GHz  -18.3  -34.3  -34.6  -21.3
! 15.01 GHz  -15.4  -34.8  -34.8  -15.1
! 16.26 GHz  -16.6  -35.1  -35.2  -25.7
! 16.95 GHz  -16.4  -35.9  -36.0  -14.3
! 17.88 GHz  -9.6  -37.4  -37.3  -11.3
! 18 GHz  -10.5  -37.2  -37.3  -12.0
