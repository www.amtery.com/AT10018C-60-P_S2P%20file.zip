!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:50:42 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -49.49 dB at 10 MHz (marker M1); lowest = -58.3 dB at 17.87 GHz (marker M2)
!   lowest |S11| = -64.4 dB at 4.9 GHz (marker M3), VSWR 1.00, Z = 49.9 + j0.0169 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (257.6 MHz wide, 1.45 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.00014
!   the Smith chart shows 10 MHz to 9.11 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -26.5  -49.5  -49.5  -24.2
! 1.72 GHz  -26.9  -50.8  -50.8  -17.4
! 3.01 GHz  -26.4  -51.3  -51.3  -20.7
! 4.01 GHz  -28.6  -51.8  -51.8  -20.5
! 4.19 GHz  -31.3  -51.9  -51.9  -20.0
! 4.52 GHz  -33.9  -52.1  -52.1  -17.3
! 4.62 GHz  -35.3  -52.1  -52.1  -18.7
! 4.79 GHz  -30.3  -52.3  -52.3  -18.2
! 4.9 GHz  -64.4  -52.3  -52.3  -19.0
! 4.97 GHz  -35.2  -52.3  -52.3  -20.3
! 5.42 GHz  -26.4  -52.6  -52.6  -28.5
! 5.6 GHz  -31.7  -52.7  -52.7  -30.4
! 6.01 GHz  -25.2  -53.0  -53.0  -22.2
! 9.01 GHz  -14.9  -54.8  -54.9  -12.1
! 11.31 GHz  -22.0  -55.3  -55.3  -14.1
! 12.01 GHz  -41.8  -55.4  -55.4  -14.5
! 12.08 GHz  -20.3  -55.5  -55.5  -14.5
! 12.57 GHz  -24.6  -55.6  -55.6  -16.1
! 15.01 GHz  -15.0  -56.6  -56.7  -19.7
! 16.8 GHz  -16.1  -57.8  -57.8  -13.7
! 17.87 GHz  -9.9  -58.3  -58.2  -21.9
! 18 GHz  -10.7  -58.1  -58.2  -18.9
