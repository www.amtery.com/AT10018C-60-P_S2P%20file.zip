!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:10:47 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -30.31 dB at 10 MHz (marker M1); lowest = -40.1 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -78.7 dB at 1.6 GHz (marker M3), VSWR 1.00, Z = 50 - j0.00271 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (253.7 MHz wide, 1.43 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -35.7 to -10.4 dB; largest |S21 - S12| = 0.0013
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -45.5  -30.3  -30.3  -24.3
! 500 MHz  -50.1  -31.1  -31.1  -23.8
! 860 MHz  -35.0  -31.3  -31.3  -21.3
! 1.6 GHz  -78.7  -31.6  -31.6  -18.7
! 2.34 GHz  -37.9  -32.0  -32.0  -17.3
! 3.01 GHz  -31.6  -32.2  -32.2  -18.8
! 3.61 GHz  -31.6  -32.6  -32.6  -25.5
! 3.79 GHz  -47.1  -32.6  -32.6  -25.0
! 4.16 GHz  -33.8  -32.8  -32.8  -22.5
! 4.98 GHz  -30.5  -33.0  -33.0  -20.0
! 5.74 GHz  -25.3  -33.4  -33.4  -29.7
! 6.01 GHz  -22.5  -33.6  -33.7  -23.5
! 6.56 GHz  -19.9  -34.1  -34.1  -17.2
! 9.01 GHz  -15.5  -35.2  -35.2  -14.6
! 10.3 GHz  -18.3  -35.6  -35.7  -10.9
! 12.01 GHz  -33.0  -35.9  -36.0  -15.2
! 13.86 GHz  -17.1  -37.2  -37.4  -21.3
! 15.01 GHz  -14.7  -37.5  -37.6  -15.1
! 16.26 GHz  -16.7  -37.9  -38.0  -25.7
! 16.95 GHz  -16.6  -38.7  -38.7  -14.3
! 17.88 GHz  -9.7  -40.1  -40.1  -11.3
! 18 GHz  -10.5  -40.0  -40.1  -12.0
