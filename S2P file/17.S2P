!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:21:14 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -20.24 dB at 10 MHz (marker M1); lowest = -30.5 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -59.8 dB at 4.95 GHz (marker M3), VSWR 1.00, Z = 50.1 - j0.0378 ohm
!   |S11| at or under -10 dB: start of sweep to 17.87 GHz; 17.9 GHz to end of sweep
!   |S22| runs from -35.4 to -10.4 dB; largest |S21 - S12| = 0.0041
!   the Smith chart shows 10 MHz to 9.03 GHz only
!   S11 on the Smith chart (normalised r, x): 10 MHz: 1.30, -0.02; 3.21 GHz: 1.02, -0.08; 9.03 GHz: 1.45, -0.26
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -17.8  -20.2  -20.3  -24.0
! 2.37 GHz  -23.8  -22.1  -22.1  -17.3
! 3.01 GHz  -30.5  -22.4  -22.4  -18.8
! 3.21 GHz  -28.0  -22.5  -22.5  -21.6
! 4.02 GHz  -24.0  -22.9  -22.9  -23.6
! 4.95 GHz  -59.8  -23.2  -23.2  -19.5
! 5.27 GHz  -31.9  -23.3  -23.3  -21.8
! 5.74 GHz  -28.2  -23.5  -23.5  -29.6
! 6.01 GHz  -30.0  -23.7  -23.7  -23.7
! 9.01 GHz  -13.2  -25.5  -25.5  -14.5
! 9.03 GHz  -13.6  -25.4  -25.5  -14.7
! 9.59 GHz  -18.2  -25.7  -25.7  -14.0
! 10.24 GHz  -24.2  -25.9  -26.0  -11.2
! 11.32 GHz  -20.7  -26.0  -26.0  -14.1
! 12.01 GHz  -28.0  -26.3  -26.4  -15.2
! 12.78 GHz  -20.9  -26.9  -27.0  -16.4
! 13.87 GHz  -17.8  -27.4  -27.6  -21.3
! 15.01 GHz  -17.8  -27.8  -27.8  -15.1
! 16.26 GHz  -16.9  -28.2  -28.3  -25.7
! 16.95 GHz  -18.4  -29.0  -29.1  -14.3
! 17.88 GHz  -9.7  -30.5  -30.5  -11.4
! 18 GHz  -10.6  -30.3  -30.4  -12.1
