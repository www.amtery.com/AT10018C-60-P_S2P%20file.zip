!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:42:52 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -58.07 dB at 60 MHz (marker M1); lowest = -66.5 dB at 17.9 GHz (marker M2)
!   lowest |S11| = -57.8 dB at 5.91 GHz (marker M3), VSWR 1.00, Z = 49.9 + j0.0944 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -47.1 to -11.1 dB; largest |S21 - S12| = 6.6e-05
!   the Smith chart shows 10 MHz to 9 GHz only
!   S11 on the Smith chart (normalised r, x): 10 MHz: 1.23, -0.01; 3.21 GHz: 0.97, -0.15; 9 GHz: 1.31, -0.10
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -19.9  -58.3  -58.3  -26.6
! 60 MHz  -20.5  -58.1  -58.1  -28.8
! 1.53 GHz  -22.4  -59.5  -59.6  -16.6
! 3.01 GHz  -24.2  -60.2  -60.2  -21.7
! 3.21 GHz  -22.4  -60.4  -60.4  -25.2
! 4.72 GHz  -28.3  -61.1  -61.1  -20.2
! 5.22 GHz  -30.1  -61.3  -61.3  -26.2
! 5.51 GHz  -33.8  -61.4  -61.4  -41.5
! 5.65 GHz  -39.4  -61.6  -61.7  -29.8
! 5.91 GHz  -57.8  -61.7  -61.7  -22.6
! 6.01 GHz  -40.7  -61.8  -61.8  -21.7
! 6.68 GHz  -30.5  -62.3  -62.3  -18.4
! 7.12 GHz  -23.4  -62.4  -62.5  -16.3
! 9 GHz  -16.9  -63.3  -63.3  -11.7
! 9.01 GHz  -16.0  -63.4  -63.4  -11.6
! 10.89 GHz  -17.1  -64.3  -64.4  -12.3
! 12.01 GHz  -23.9  -64.5  -64.5  -14.3
! 14.55 GHz  -21.0  -65.1  -65.2  -22.9
! 15.01 GHz  -19.2  -64.7  -64.8  -21.7
! 17.12 GHz  -18.8  -65.4  -65.4  -18.0
! 17.9 GHz  -12.2  -66.5  -66.0  -13.8
! 18 GHz  -12.9  -66.2  -66.4  -13.1
