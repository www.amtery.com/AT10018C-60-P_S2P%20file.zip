!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:27:51 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -14.44 dB at 10 MHz (marker M1); lowest = -23.7 dB at 17.18 GHz (marker M2)
!   lowest |S11| = -70.4 dB at 1 GHz (marker M3), VSWR 1.00, Z = 50 + j0.0031 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.87 GHz (253.8 MHz wide, 1.43 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -41.5 to -9.6 dB; largest |S21 - S12| = 0.0081
!   the Smith chart shows 10 MHz to 8.68 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -40.7  -14.4  -14.5  -15.6
! 470 MHz  -47.3  -15.3  -15.3  -27.8
! 860 MHz  -33.9  -15.5  -15.5  -19.6
! 1 GHz  -70.4  -15.6  -15.6  -19.9
! 2.33 GHz  -35.6  -16.2  -16.3  -19.6
! 3.01 GHz  -31.8  -16.6  -16.6  -20.3
! 4.33 GHz  -33.4  -17.1  -17.1  -16.2
! 4.79 GHz  -36.1  -17.4  -17.4  -32.9
! 5.12 GHz  -27.3  -17.4  -17.4  -19.4
! 6.01 GHz  -21.5  -17.9  -17.9  -23.1
! 6.69 GHz  -20.0  -18.7  -18.7  -13.4
! 7.16 GHz  -19.9  -18.2  -18.2  -40.2
! 7.53 GHz  -23.5  -18.6  -18.7  -15.3
! 9.01 GHz  -15.5  -19.3  -19.3  -12.7
! 12.01 GHz  -32.8  -20.2  -20.3  -15.3
! 13.36 GHz  -14.1  -21.0  -21.1  -16.7
! 13.69 GHz  -15.6  -21.3  -21.2  -29.6
! 14.03 GHz  -15.0  -21.8  -21.9  -15.9
! 15.01 GHz  -14.6  -22.2  -22.2  -16.1
! 15.35 GHz  -13.5  -22.1  -22.1  -30.4
! 17.18 GHz  -10.8  -23.7  -23.7  -12.0
! 18 GHz  -10.6  -23.2  -23.3  -24.4
