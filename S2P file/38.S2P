!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:59:00 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -41.47 dB at 10 MHz (marker M1); lowest = -50.5 dB at 17.91 GHz (marker M2)
!   lowest |S11| = -72.5 dB at 5.84 GHz (marker M3), VSWR 1.00, Z = 50 - j0.0229 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -36.2 to -11.4 dB; largest |S21 - S12| = 0.00034
!   the Smith chart shows 10 MHz to 9.1 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -20.0  -41.5  -41.5  -24.3
! 1.72 GHz  -21.9  -42.8  -42.8  -17.4
! 3.01 GHz  -23.5  -43.4  -43.4  -20.7
! 3.53 GHz  -24.3  -43.6  -43.6  -23.2
! 4.73 GHz  -29.1  -44.3  -44.3  -19.2
! 5.11 GHz  -29.2  -44.4  -44.4  -21.7
! 5.32 GHz  -28.4  -44.6  -44.6  -25.3
! 5.6 GHz  -32.5  -44.8  -44.8  -30.4
! 5.84 GHz  -72.5  -45.0  -45.0  -27.0
! 5.91 GHz  -33.2  -45.1  -45.1  -23.2
! 6.01 GHz  -31.6  -45.1  -45.2  -22.2
! 7.96 GHz  -20.0  -46.3  -46.3  -13.5
! 9.01 GHz  -15.8  -47.0  -47.0  -12.1
! 12.01 GHz  -25.3  -47.7  -47.7  -14.5
! 12.06 GHz  -19.2  -47.8  -47.8  -14.6
! 12.56 GHz  -27.7  -47.9  -47.9  -16.1
! 15.01 GHz  -18.4  -48.8  -48.9  -19.7
! 16.69 GHz  -22.9  -49.9  -50.0  -13.6
! 17.29 GHz  -16.1  -50.2  -50.3  -16.9
! 17.72 GHz  -13.3  -50.3  -50.4  -23.7
! 17.91 GHz  -12.9  -50.5  -50.5  -22.4
! 18 GHz  -12.9  -50.4  -50.5  -18.9
