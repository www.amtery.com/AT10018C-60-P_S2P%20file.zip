!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:06:42 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -34.30 dB at 10 MHz (marker M1); lowest = -44.0 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -70.7 dB at 250 MHz (marker M3), VSWR 1.00, Z = 50 + j0.0163 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (253.4 MHz wide, 1.43 % of centre); 17.89 GHz to end of sweep
!   |S22| runs from -35.8 to -10.5 dB; largest |S21 - S12| = 0.00083
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -65.8  -34.3  -34.3  -24.3
! 110 MHz  -46.6  -34.7  -34.7  -26.2
! 250 MHz  -70.7  -34.9  -34.9  -25.8
! 390 MHz  -41.3  -35.0  -35.0  -24.8
! 710 MHz  -53.7  -35.2  -35.2  -22.2
! 860 MHz  -37.6  -35.2  -35.2  -21.3
! 3.01 GHz  -31.5  -36.2  -36.2  -18.8
! 3.61 GHz  -32.1  -36.5  -36.5  -25.6
! 3.79 GHz  -43.5  -36.6  -36.6  -25.0
! 4.98 GHz  -30.3  -37.0  -37.0  -20.0
! 5.74 GHz  -24.2  -37.4  -37.4  -29.7
! 6.01 GHz  -21.5  -37.6  -37.7  -23.5
! 6.56 GHz  -19.4  -38.1  -38.1  -17.2
! 9.01 GHz  -15.6  -39.1  -39.2  -14.6
! 11.64 GHz  -20.5  -39.7  -39.8  -14.2
! 12.01 GHz  -31.7  -39.9  -40.0  -15.2
! 13.86 GHz  -16.9  -41.1  -41.4  -21.3
! 15.01 GHz  -14.4  -41.5  -41.5  -15.1
! 16.26 GHz  -16.7  -41.9  -42.0  -25.7
! 16.95 GHz  -16.5  -42.6  -42.7  -14.4
! 17.88 GHz  -9.7  -44.0  -44.0  -11.4
! 18 GHz  -10.5  -43.9  -44.0  -12.1
