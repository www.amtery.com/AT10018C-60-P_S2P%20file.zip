!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:55:02 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -45.45 dB at 10 MHz (marker M1); lowest = -54.4 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -54.3 dB at 5.31 GHz (marker M3), VSWR 1.00, Z = 50.2 + j0.112 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (254.7 MHz wide, 1.44 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.00023
!   the Smith chart shows 10 MHz to 9.1 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -25.5  -45.5  -45.5  -24.2
! 1.72 GHz  -26.3  -46.8  -46.8  -17.4
! 3.01 GHz  -26.4  -47.3  -47.3  -20.7
! 3.53 GHz  -27.4  -47.6  -47.6  -23.2
! 4.01 GHz  -29.1  -47.8  -47.8  -20.5
! 4.19 GHz  -31.6  -47.9  -47.9  -20.0
! 4.52 GHz  -32.9  -48.1  -48.1  -17.3
! 4.72 GHz  -37.4  -48.2  -48.2  -19.2
! 4.8 GHz  -30.2  -48.3  -48.2  -18.3
! 4.99 GHz  -34.4  -48.3  -48.3  -20.3
! 5.31 GHz  -54.3  -48.5  -48.5  -25.0
! 5.6 GHz  -33.3  -48.7  -48.7  -30.4
! 6.01 GHz  -25.5  -49.1  -49.1  -22.2
! 7.95 GHz  -19.4  -50.2  -50.2  -13.7
! 9.01 GHz  -14.8  -50.9  -50.9  -12.1
! 10.95 GHz  -40.7  -51.3  -51.3  -14.4
! 11.31 GHz  -21.3  -51.3  -51.4  -14.1
! 12.01 GHz  -37.3  -51.4  -51.5  -14.5
! 15.01 GHz  -15.1  -52.7  -52.7  -19.7
! 16.8 GHz  -16.1  -53.9  -53.9  -13.7
! 17.88 GHz  -9.7  -54.4  -54.3  -22.2
! 18 GHz  -10.6  -54.2  -54.4  -18.9
