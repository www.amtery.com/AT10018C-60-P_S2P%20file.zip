!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:09:53 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -31.33 dB at 10 MHz (marker M1); lowest = -41.3 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -54.2 dB at 4.9 GHz (marker M3), VSWR 1.00, Z = 50.2 + j0.118 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (255.7 MHz wide, 1.44 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -35.7 to -10.4 dB; largest |S21 - S12| = 0.0011
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -25.9  -31.3  -31.3  -24.2
! 3.01 GHz  -26.6  -33.4  -33.3  -18.8
! 3.78 GHz  -28.3  -33.7  -33.7  -24.9
! 4.51 GHz  -32.2  -34.1  -34.1  -19.4
! 4.62 GHz  -35.9  -34.1  -34.1  -20.3
! 4.78 GHz  -30.3  -34.1  -34.1  -18.8
! 4.9 GHz  -54.2  -34.1  -34.1  -19.1
! 5.42 GHz  -27.1  -34.3  -34.3  -24.1
! 5.74 GHz  -31.4  -34.5  -34.5  -29.7
! 6.01 GHz  -26.2  -34.7  -34.7  -23.6
! 6.56 GHz  -21.9  -35.2  -35.2  -17.2
! 9.01 GHz  -14.8  -36.4  -36.4  -14.6
! 10.22 GHz  -25.4  -36.8  -36.8  -11.2
! 11.31 GHz  -22.3  -36.8  -36.9  -14.0
! 12.01 GHz  -42.4  -37.1  -37.2  -15.2
! 12.08 GHz  -20.3  -37.3  -37.3  -15.4
! 13.86 GHz  -18.2  -38.3  -38.6  -21.3
! 15.01 GHz  -15.1  -38.7  -38.8  -15.1
! 16.26 GHz  -16.9  -39.1  -39.2  -25.7
! 16.95 GHz  -16.5  -39.9  -39.9  -14.3
! 17.88 GHz  -9.7  -41.3  -41.3  -11.3
! 18 GHz  -10.7  -41.1  -41.2  -12.0
