!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:38:36 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -62.09 dB at 60 MHz (marker M1); lowest = -70.3 dB at 17.92 GHz (marker M2)
!   lowest |S11| = -61.8 dB at 4.68 GHz (marker M3), VSWR 1.00, Z = 50.1 - j0.0609 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (253.8 MHz wide, 1.43 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -47.2 to -11.1 dB; largest |S21 - S12| = 4.8e-05
!   the Smith chart shows 10 MHz to 9.01 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -25.4  -62.3  -62.3  -26.6
! 60 MHz  -26.2  -62.1  -62.1  -28.8
! 1.53 GHz  -27.8  -63.5  -63.5  -16.6
! 3.01 GHz  -26.8  -64.1  -64.1  -21.7
! 4.52 GHz  -32.1  -64.9  -64.9  -17.4
! 4.68 GHz  -61.8  -65.1  -65.1  -18.8
! 4.8 GHz  -29.6  -65.0  -65.0  -19.3
! 4.98 GHz  -34.8  -65.0  -65.0  -21.8
! 5.21 GHz  -33.5  -65.2  -65.2  -25.9
! 5.5 GHz  -38.0  -65.3  -65.3  -39.8
! 6.01 GHz  -26.6  -65.7  -65.7  -21.7
! 7.94 GHz  -19.7  -66.5  -66.5  -15.5
! 9.01 GHz  -15.2  -67.0  -67.0  -11.6
! 10.09 GHz  -26.8  -67.3  -67.4  -12.1
! 10.73 GHz  -18.9  -67.8  -67.9  -12.2
! 12.01 GHz  -39.9  -68.2  -68.1  -14.3
! 12.08 GHz  -20.6  -68.4  -68.2  -14.4
! 13.14 GHz  -21.5  -68.3  -68.3  -17.4
! 15.01 GHz  -15.3  -69.1  -68.8  -21.7
! 17.12 GHz  -14.8  -69.6  -69.0  -18.0
! 17.92 GHz  -11.5  -70.3  -69.6  -13.7
! 18 GHz  -10.6  -69.9  -69.8  -13.1
