!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Fri Sep 30 15:49:46 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -51.95 dB at 60 MHz (marker M1); lowest = -60.4 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -48.8 dB at 12.25 GHz (marker M3), VSWR 1.01, Z = 49.9 - j0.355 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.62 GHz to 17.73 GHz (106.3 MHz wide, 0.601 % of centre); 17.75 GHz to 17.86 GHz (105.2 MHz wide, 0.591 % of centre) (the widest 3 of 4)
!   |S22| runs from -47.3 to -11.1 dB; largest |S21 - S12| = 0.00013
!   the Smith chart shows 10.97 GHz to 13.78 GHz only
!   S11 on the Smith chart (normalised r, x): 10.97 GHz: 1.06, -0.05; 11.46 GHz: 1.36, +0.05; 13.78 GHz: 0.94, +0.20
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -13.4  -52.1  -52.2  -26.6
! 60 MHz  -14.1  -51.9  -52.0  -28.8
! 1.53 GHz  -16.1  -53.5  -53.5  -16.6
! 3.01 GHz  -21.7  -54.3  -54.3  -21.7
! 4.72 GHz  -19.9  -55.1  -55.1  -20.2
! 5.22 GHz  -24.4  -55.3  -55.3  -26.2
! 5.51 GHz  -25.6  -55.5  -55.5  -41.7
! 6.01 GHz  -29.0  -55.8  -55.8  -21.6
! 6.99 GHz  -16.3  -56.3  -56.3  -16.6
! 8.31 GHz  -16.1  -57.3  -57.4  -14.9
! 9.01 GHz  -13.3  -57.6  -57.6  -11.6
! 9.8 GHz  -18.7  -57.8  -57.8  -11.3
! 10.45 GHz  -16.8  -57.8  -57.8  -12.1
! 10.97 GHz  -28.3  -58.4  -58.4  -12.5
! 11.46 GHz  -16.3  -58.4  -58.4  -13.1
! 12.01 GHz  -20.3  -58.5  -58.5  -14.3
! 12.25 GHz  -48.8  -58.6  -58.5  -15.0
! 13.51 GHz  -22.1  -58.8  -58.8  -19.0
! 13.78 GHz  -19.6  -58.3  -58.7  -19.2
! 15.01 GHz  -15.6  -58.9  -59.0  -21.7
! 17.89 GHz  -9.3  -60.4  -60.4  -13.8
! 18 GHz  -10.2  -60.3  -60.5  -13.1
