!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:12:36 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -28.27 dB at 10 MHz (marker M1); lowest = -38.2 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -71.1 dB at 3.79 GHz (marker M3), VSWR 1.00, Z = 50 + j0.0218 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (247.6 MHz wide, 1.4 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -35.6 to -10.4 dB; largest |S21 - S12| = 0.0016
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -37.1  -28.3  -28.3  -24.1
! 480 MHz  -39.3  -29.0  -29.0  -24.1
! 850 MHz  -31.9  -29.2  -29.3  -21.2
! 1.01 GHz  -43.5  -29.3  -29.3  -20.7
! 2.34 GHz  -35.0  -30.0  -30.0  -17.3
! 2.74 GHz  -40.3  -30.2  -30.2  -17.7
! 3.01 GHz  -31.1  -30.3  -30.3  -18.8
! 3.62 GHz  -31.9  -30.6  -30.7  -24.9
! 3.79 GHz  -71.1  -30.7  -30.7  -25.1
! 4.34 GHz  -32.2  -30.9  -30.9  -22.6
! 5.11 GHz  -26.6  -31.1  -31.1  -20.6
! 5.74 GHz  -26.1  -31.4  -31.4  -29.6
! 6.01 GHz  -23.1  -31.7  -31.7  -23.6
! 9.01 GHz  -15.1  -33.3  -33.3  -14.6
! 10.59 GHz  -19.4  -33.7  -33.8  -11.8
! 12.01 GHz  -33.7  -34.0  -34.1  -15.2
! 13.86 GHz  -17.0  -35.2  -35.5  -21.3
! 15.01 GHz  -14.7  -35.7  -35.7  -15.1
! 16.26 GHz  -16.4  -35.9  -36.0  -25.7
! 16.95 GHz  -16.3  -36.8  -36.8  -14.3
! 17.88 GHz  -9.6  -38.2  -38.2  -11.3
! 18 GHz  -10.4  -38.0  -38.1  -12.0
