!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:11:42 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -29.32 dB at 10 MHz (marker M1); lowest = -39.3 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -49.5 dB at 4.9 GHz (marker M3), VSWR 1.01, Z = 50.3 - j0.171 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (257.7 MHz wide, 1.45 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -35.7 to -10.4 dB; largest |S21 - S12| = 0.0014
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -25.6  -29.3  -29.3  -24.3
! 3.01 GHz  -27.2  -31.3  -31.3  -18.8
! 3.78 GHz  -28.5  -31.7  -31.7  -24.8
! 4.51 GHz  -32.0  -32.0  -32.0  -19.4
! 4.62 GHz  -35.3  -32.1  -32.0  -20.3
! 4.79 GHz  -30.9  -32.0  -32.0  -18.7
! 4.9 GHz  -49.5  -32.0  -32.0  -19.1
! 5.41 GHz  -27.5  -32.2  -32.2  -24.0
! 5.74 GHz  -33.5  -32.4  -32.4  -29.7
! 6.01 GHz  -27.4  -32.7  -32.7  -23.5
! 6.56 GHz  -22.3  -33.2  -33.2  -17.2
! 9.01 GHz  -14.8  -34.3  -34.3  -14.6
! 10.22 GHz  -24.6  -34.7  -34.8  -11.2
! 11.31 GHz  -21.8  -34.8  -34.8  -14.0
! 12.01 GHz  -38.8  -35.0  -35.1  -15.2
! 13.86 GHz  -18.6  -36.2  -36.5  -21.3
! 15.01 GHz  -15.5  -36.7  -36.7  -15.1
! 15.8 GHz  -13.7  -37.0  -36.9  -20.3
! 16.26 GHz  -17.0  -37.0  -37.1  -25.7
! 16.95 GHz  -16.7  -37.8  -37.9  -14.3
! 17.88 GHz  -9.7  -39.3  -39.3  -11.3
! 18 GHz  -10.7  -39.1  -39.2  -12.0
