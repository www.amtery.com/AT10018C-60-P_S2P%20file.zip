!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 14:53:03 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -47.46 dB at 10 MHz (marker M1); lowest = -56.4 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -53.2 dB at 4.67 GHz (marker M3), VSWR 1.00, Z = 50.2 + j0.0023 ohm
!   |S11| at or under -10 dB: start of sweep to 17.6 GHz; 17.61 GHz to 17.87 GHz (254.2 MHz wide, 1.43 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -36.1 to -11.4 dB; largest |S21 - S12| = 0.00018
!   the Smith chart shows 10 MHz to 9.11 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -25.7  -47.5  -47.5  -24.2
! 1.72 GHz  -26.3  -48.8  -48.8  -17.4
! 3.01 GHz  -26.0  -49.4  -49.4  -20.7
! 3.53 GHz  -26.8  -49.6  -49.7  -23.2
! 4.01 GHz  -28.3  -49.9  -49.9  -20.5
! 4.52 GHz  -33.3  -50.2  -50.1  -17.3
! 4.67 GHz  -53.2  -50.2  -50.2  -17.7
! 4.79 GHz  -29.8  -50.3  -50.3  -18.2
! 4.98 GHz  -34.1  -50.3  -50.3  -20.3
! 5.42 GHz  -26.4  -50.6  -50.6  -28.5
! 5.6 GHz  -32.0  -50.8  -50.8  -30.4
! 6.01 GHz  -25.2  -51.1  -51.1  -22.2
! 9.01 GHz  -14.8  -52.9  -53.0  -12.1
! 11.31 GHz  -21.9  -53.4  -53.4  -14.1
! 12.01 GHz  -39.9  -53.5  -53.5  -14.5
! 12.08 GHz  -20.5  -53.6  -53.6  -14.5
! 12.57 GHz  -24.5  -53.7  -53.7  -16.1
! 15.01 GHz  -14.9  -54.7  -54.8  -19.7
! 16.8 GHz  -16.0  -55.9  -55.9  -13.7
! 17.72 GHz  -10.8  -56.1  -56.2  -23.7
! 17.89 GHz  -9.8  -56.4  -56.3  -22.4
! 18 GHz  -10.6  -56.3  -56.3  -18.9
