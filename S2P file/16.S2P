!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:22:11 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -19.17 dB at 10 MHz (marker M1); lowest = -29.6 dB at 17.89 GHz (marker M2)
!   lowest |S11| = -40.4 dB at 12.55 GHz (marker M3), VSWR 1.02, Z = 49.4 - j0.748 ohm
!   |S11| at or under -10 dB: start of sweep to 17.87 GHz; 17.9 GHz to end of sweep
!   |S22| runs from -35.2 to -10.4 dB; largest |S21 - S12| = 0.0045
!   the Smith chart shows 11.21 GHz to 14.03 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -13.5  -19.2  -19.2  -23.9
! 3.01 GHz  -23.7  -21.4  -21.4  -18.9
! 4.01 GHz  -18.5  -21.9  -21.9  -23.8
! 4.73 GHz  -24.1  -22.2  -22.2  -20.2
! 5.33 GHz  -25.0  -22.4  -22.3  -22.6
! 5.74 GHz  -20.8  -22.5  -22.5  -29.5
! 6.01 GHz  -19.9  -22.7  -22.7  -23.7
! 6.55 GHz  -18.4  -23.2  -23.2  -17.2
! 7.61 GHz  -20.2  -23.8  -23.8  -16.6
! 8.4 GHz  -13.6  -24.3  -24.3  -12.3
! 9.01 GHz  -12.2  -24.6  -24.6  -14.5
! 9.6 GHz  -16.4  -24.8  -24.8  -13.9
! 10.24 GHz  -18.9  -25.0  -25.1  -11.2
! 12.01 GHz  -22.9  -25.4  -25.5  -15.2
! 12.55 GHz  -40.4  -25.9  -25.9  -16.5
! 13.11 GHz  -20.9  -26.1  -26.1  -16.8
! 13.86 GHz  -19.3  -26.4  -26.7  -21.3
! 15.01 GHz  -18.4  -26.8  -26.9  -15.1
! 16.26 GHz  -17.0  -27.4  -27.5  -25.7
! 16.95 GHz  -18.3  -28.2  -28.2  -14.3
! 17.89 GHz  -9.6  -29.6  -29.6  -11.5
! 18 GHz  -10.6  -29.5  -29.6  -12.1
