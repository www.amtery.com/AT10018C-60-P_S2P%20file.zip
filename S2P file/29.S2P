!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:08:55 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -32.30 dB at 10 MHz (marker M1); lowest = -42.1 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -67.9 dB at 510 MHz (marker M3), VSWR 1.00, Z = 50 - j0.0291 ohm
!   |S11| at or under -10 dB: start of sweep to 17.59 GHz; 17.61 GHz to 17.86 GHz (251.3 MHz wide, 1.42 % of centre); 17.9 GHz to end of sweep
!   |S22| runs from -35.7 to -10.4 dB; largest |S21 - S12| = 0.001
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -50.8  -32.3  -32.3  -24.2
! 510 MHz  -67.9  -33.1  -33.1  -23.8
! 860 MHz  -35.9  -33.3  -33.3  -21.2
! 1.54 GHz  -39.0  -33.6  -33.6  -18.8
! 2.34 GHz  -38.5  -34.0  -34.0  -17.3
! 3.01 GHz  -31.4  -34.3  -34.3  -18.8
! 3.61 GHz  -32.4  -34.6  -34.6  -25.5
! 3.79 GHz  -45.7  -34.7  -34.7  -25.1
! 4.17 GHz  -35.2  -34.9  -34.9  -22.8
! 4.98 GHz  -30.4  -35.1  -35.1  -20.0
! 5.74 GHz  -24.7  -35.4  -35.4  -29.7
! 6.01 GHz  -21.9  -35.7  -35.7  -23.6
! 6.56 GHz  -19.5  -36.2  -36.1  -17.2
! 9.01 GHz  -15.5  -37.2  -37.2  -14.6
! 10.59 GHz  -20.0  -37.6  -37.7  -11.8
! 12.01 GHz  -31.9  -38.0  -38.1  -15.2
! 13.86 GHz  -16.8  -39.2  -39.5  -21.3
! 15.01 GHz  -14.4  -39.6  -39.6  -15.1
! 16.26 GHz  -16.6  -39.9  -40.0  -25.7
! 16.95 GHz  -16.4  -40.7  -40.8  -14.3
! 17.88 GHz  -9.7  -42.1  -42.1  -11.4
! 18 GHz  -10.5  -42.0  -42.0  -12.0
