!Agilent Technologies,E5071C,MY46316741,A.11.02
!Date: Thu Sep 29 15:02:05 2022
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   1800 points, 10 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -38.46 dB at 10 MHz (marker M1); lowest = -47.5 dB at 17.88 GHz (marker M2)
!   lowest |S11| = -64.8 dB at 5.67 GHz (marker M3), VSWR 1.00, Z = 50 - j0.0568 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -36.2 to -11.4 dB; largest |S21 - S12| = 0.00049
!   the Smith chart shows 10 MHz to 9.09 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -22.6  -38.5  -38.5  -24.2
! 1.72 GHz  -26.0  -39.8  -39.8  -17.4
! 3.01 GHz  -30.2  -40.4  -40.4  -20.7
! 3.45 GHz  -41.5  -40.6  -40.6  -26.1
! 4.14 GHz  -28.3  -40.9  -40.9  -19.3
! 4.94 GHz  -28.2  -41.4  -41.3  -19.5
! 5.41 GHz  -37.7  -41.7  -41.7  -28.5
! 5.67 GHz  -64.8  -41.9  -41.9  -32.6
! 5.9 GHz  -30.9  -42.0  -42.1  -23.4
! 6.01 GHz  -27.5  -42.1  -42.2  -22.2
! 6.63 GHz  -26.1  -42.4  -42.4  -18.4
! 7.18 GHz  -29.0  -42.5  -42.5  -17.6
! 7.95 GHz  -19.8  -43.2  -43.2  -13.7
! 9.01 GHz  -16.0  -43.9  -43.9  -12.1
! 9.6 GHz  -18.3  -44.2  -44.2  -11.9
! 10.68 GHz  -26.3  -44.4  -44.5  -14.2
! 11.46 GHz  -18.7  -44.6  -44.6  -14.1
! 12.01 GHz  -27.5  -44.6  -44.6  -14.5
! 15.01 GHz  -16.5  -45.8  -45.8  -19.7
! 16.8 GHz  -18.7  -46.9  -47.0  -13.7
! 17.88 GHz  -10.2  -47.5  -47.5  -22.2
! 18 GHz  -11.2  -47.4  -47.5  -18.9
